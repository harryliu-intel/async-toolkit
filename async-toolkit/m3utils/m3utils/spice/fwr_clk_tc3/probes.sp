.probe tran v(bzmnotchwrap/bzmnotch/bzmgio/gpio_trip_rx_out/orxout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1779_130115/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1649_f_130114/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1437_130113/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_359_130112/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux/ctech_clk_mux/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_131225/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1152_129793/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_312_129790/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_216_129789/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/u_eng_clk0_lvlshift0_ctech_lvlshift/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/u_eng_clk0_lvlshift1_ctech_lvlshift/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/u0_gdsi00bb1c84x5/ctech_inv_lvlshift/clkout)
.probe tran v(right_stack_inst/sp_fast_clk_right_i)
.probe tran v(right_stack_inst/mgtile_channel_l0r1/SPINE_BUF_0_spine_buf_eng_clk0/ctech_lvlshift/clkout)
.probe tran v(right_stack_inst/mgtile_channel_l0r1/SPINE_BUF_0_spine_buf_eng_clk1/ctech_lvlshift/clkout)
.probe tran v(right_stack_inst/mgtile_channel_l0r1/SPINE_BUF_1_spine_buf_eng_clk0/ctech_lvlshift/clkout)
.probe tran v(right_stack_inst/mgtile_channel_l0r1/SPINE_BUF_1_spine_buf_eng_clk1/ctech_lvlshift/clkout)
.probe tran v(right_stack_inst/mgtile_channel_l0r1/SPINE_BUF_2_spine_buf_eng_clk0/ctech_lvlshift/clkout)
.probe tran v(right_stack_inst/mgtile_channel_l0r1/SPINE_BUF_2_spine_buf_eng_clk1/ctech_lvlshift/clkout)
.probe tran v(right_stack_inst/mgtile_channel_l0r1/SPINE_BUF_3_spine_buf_eng_clk0/ctech_lvlshift/clkout)
.probe tran v(right_stack_inst/mgtile_channel_l0r1/SPINE_BUF_3_spine_buf_eng_clk1/ctech_lvlshift/clkout)
.probe tran v(right_stack_inst/mgtile_channel_l0r1/SPINE_BUF_4_spine_buf_eng_clk0/ctech_lvlshift/clkout)
.probe tran v(right_stack_inst/mgtile_channel_l0r1/SPINE_BUF_4_spine_buf_eng_clk1/ctech_lvlshift/clkout)
.probe tran v(right_stack_inst/mgtile_channel_l0r1/SPINE_BUF_5_spine_buf_eng_clk0/ctech_lvlshift/clkout)
.probe tran v(right_stack_inst/mgtile_channel_l0r1/SPINE_BUF_5_spine_buf_eng_clk1/ctech_lvlshift/clkout)
.probe tran v(right_stack_inst/mgtile_channel_l0r1/SPINE_BUF_6_spine_buf_eng_clk0/ctech_lvlshift/clkout)
.probe tran v(right_stack_inst/mgtile_channel_l0r1/SPINE_BUF_6_spine_buf_eng_clk1/ctech_lvlshift/clkout)
.probe tran v(right_stack_inst/mgtile_channel_l0r1/SPINE2PAR_BUF_15_RIGHT_STACK_spine2par_buf_eng_clk/ctech_lvlshift/clkout)
.probe tran v(right_stack_inst/mgtile_channel_l0r1/SPINE2PAR_BUF_15_RIGHT_STACK_ENG_CLK_left/ctech_lvlshift/clkout)
.probe tran v(right_stack_inst/mgtile_inst0/OCTA14_i_octa_wrapper_14/eng_divclk1)
