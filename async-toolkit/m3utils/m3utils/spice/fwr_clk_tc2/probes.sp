.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/clk1)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/clk2)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/s)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_VCC)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/clock_opt_cts_ZCTSINV_745_138433/clk)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/clock_opt_cts_ZCTSINV_745_138433/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210_VCC)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212_VCC)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088_VCC)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124089/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124089/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124089_VCC)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140568/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140568/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140568_VCC)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140569/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140569/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140569_VCC)
.probe tran v(bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clk1)
.probe tran v(bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clk2)
.probe tran v(bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/clk)
.probe tran v(bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211_VCC)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/clock_opt_cts_engclk_i_vtd123961/clk)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/clock_opt_cts_engclk_i_vtd123961/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/clock_opt_cts_engclk_i_vtd123961_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_255/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_255/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_255_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_256/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_256/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_256_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_258/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_258/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_258_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_259/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_259/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_259_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_260/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_260/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_260_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_261/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_261/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_261_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_262/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_262/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_262_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_263/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_263/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_263_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_264/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_264/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_264_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_265/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_265/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_265_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_266/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_266/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_266_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_267/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_267/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_267_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_268/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_268/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_268_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_269/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_269/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_269_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_270/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_270/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_270_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_271/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_271/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_271_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_272/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_272/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_272_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_273/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_273/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_273_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_274/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_274/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_274_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_275/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_275/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_275_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_276/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_276/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_276_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_277/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_277/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_277_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_278/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_278/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_278_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_279/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_279/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_279_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_280/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_280/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_280_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_281/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_281/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_281_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_282/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_282/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_282_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_283/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_283/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_283_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_284/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_284/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_284_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_285/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_285/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_285_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_286/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_286/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_286_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_287/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_287/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_287_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_288/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_288/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_288_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_289/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_289/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_289_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_290/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_290/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_290_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_eng_rt_focal_buf/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_eng_rt_focal_buf/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_eng_rt_focal_buf_VCC)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/U36/clk)
.probe tran v(right_stack_inst/mgtile_inst3/U36/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/U36_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_291/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_291/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_291_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_292/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_292/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_292_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_293/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_293/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_293_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_294/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_294/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_294_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_295/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_295/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_295_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_296/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_296/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_296_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_297/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_297/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_297_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_298/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_298/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_298_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_299/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_299/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_299_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_300/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_300/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_300_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_301/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_301/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_301_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_302/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_302/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_302_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_303/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_303/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_303_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_304/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_304/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_304_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_305/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_305/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_305_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_306/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_306/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_306_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_307/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_307/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_307_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_308/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_308/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_308_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_309/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_309/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_309_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_310/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_310/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_310_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_311/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_311/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_311_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_312/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_312/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_312_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_313/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_313/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_313_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_314/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_314/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_314_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_315/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_315/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_315_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_316/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_316/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_316_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_317/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_317/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_317_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_318/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_318/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_318_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_319/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_319/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_319_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_320/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_320/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_320_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_321/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_321/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_321_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_322/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_322/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_322_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_323/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_323/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_323_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_324/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_324/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_324_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_325/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_325/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_325_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_326/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_326/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_326_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_327/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_327/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_327_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_328/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_328/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_328_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_329/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_329/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_329_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_330/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_330/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_330_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_331/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_331/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_331_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_332/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_332/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_332_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_333/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_333/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_333_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_334/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_334/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_334_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_335/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_335/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_335_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_336/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_336/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_336_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_337/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_337/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_337_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_338/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_338/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_338_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_339/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_339/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_339_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_340/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_340/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_340_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_341/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_341/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_341_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_rt_3_sch/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_rt_3_sch/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_rt_3_sch_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux)
.probe tran v(xbzmnotchwrap/bzmnotch/bzmpll_inst0/clock_opt_cts_ZCTSINV_745_138433)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124089)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140568)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140569)
.probe tran v(xbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux)
.probe tran v(xbzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211)
.probe tran v(xbzmnotchwrap/bzmnotch/notch_dcc_inst0/clock_opt_cts_engclk_i_vtd123961)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_255)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_256)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_258)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_259)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_260)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_261)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_262)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_263)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_264)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_265)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_266)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_267)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_268)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_269)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_270)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_271)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_272)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_273)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_274)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_275)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_276)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_277)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_278)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_279)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_280)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_281)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_282)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_283)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_284)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_285)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_286)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_287)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_288)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_289)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_290)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_eng_rt_focal_buf)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift)
.probe tran v(xright_stack_inst/mgtile_inst3/U36)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_291)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_292)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_293)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_294)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_295)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_296)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_297)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_298)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_299)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_300)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_301)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_302)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_303)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_304)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_305)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_306)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_307)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_308)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_309)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_310)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_311)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_312)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_313)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_314)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_315)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_316)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_317)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_318)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_319)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_320)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_321)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_322)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_323)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_324)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_325)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_326)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_327)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_328)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_329)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_330)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_331)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_332)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_333)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_334)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_335)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_336)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_337)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_338)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_339)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_340)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_341)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_rt_3_sch)
