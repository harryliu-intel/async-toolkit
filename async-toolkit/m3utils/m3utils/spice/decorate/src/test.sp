.include 'include.sp'
.include '/nfs/site/disks/zsc9_fwr_sd_001/mnystroe/adder/adder_tb_Width32_MaxCarryChain31_AdderType2_85C_tttt.spf'

Xdut clk
+a_i[31] a_i[30] a_i[29] a_i[28] a_i[27] a_i[26] a_i[25] a_i[24] a_i[23] a_i[22] a_i[21] a_i[20] a_i[19] a_i[18] a_i[17] a_i[16] a_i[15] a_i[14] a_i[13] a_i[12] a_i[11] a_i[10] a_i[9] a_i[8] a_i[7] a_i[6] a_i[5] a_i[4] a_i[3] a_i[2] a_i[1] a_i[0]
+b_i[31] b_i[30] b_i[29] b_i[28] b_i[27] b_i[26] b_i[25] b_i[24] b_i[23] b_i[22] b_i[21] b_i[20] b_i[19] b_i[18] b_i[17] b_i[16] b_i[15] b_i[14] b_i[13] b_i[12] b_i[11] b_i[10] b_i[9] b_i[8] b_i[7] b_i[6] b_i[5] b_i[4] b_i[3] b_i[2] b_i[1] b_i[0]
+y_o[31] y_o[30] y_o[29] y_o[28] y_o[27] y_o[26] y_o[25] y_o[24] y_o[23] y_o[22] y_o[21] y_o[20] y_o[19] y_o[18] y_o[17] y_o[16] y_o[15] y_o[14] y_o[13] y_o[12] y_o[11] y_o[10] y_o[9] y_o[8] y_o[7] y_o[6] y_o[5] y_o[4] y_o[3] y_o[2] y_o[1] y_o[0]
+y_d[31] y_d[30] y_d[29] y_d[28] y_d[27] y_d[26] y_d[25] y_d[24] y_d[23] y_d[22] y_d[21] y_d[20] y_d[19] y_d[18] y_d[17] y_d[16] y_d[15] y_d[14] y_d[13] y_d[12] y_d[11] y_d[10] y_d[9] y_d[8] y_d[7] y_d[6] y_d[5] y_d[4] y_d[3] y_d[2] y_d[1] y_d[0]
+vcc vcc1 vssx adder_tb_Width32_MaxCarryChain31_AdderType2
