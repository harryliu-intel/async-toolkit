.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_2to1/a)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_2to1/b)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1/a)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1/b)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1_C_SPC0/a)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1_C_SPC0/b)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/ctmi_225/a)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/ctmi_225/o1)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/ctmi_225_VCC)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/fast_clk_count_reg_0/clk)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/fast_clk_count_reg_0/d)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/pll_fast_clk_by2_reg/clk)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/pll_fast_clk_by2_reg/d)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/pwc_clk_gate_fast_clk_count_reg_1/clk)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/pwc_clk_gate_fast_clk_count_reg_1/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_57/a)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_57/b)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_58/clk)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_58/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_58_VCC)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67/a)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67/b)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67_2inv_eco_cell/clk)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67_2inv_eco_cell/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67_2inv_eco_cell_VCC)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_72/a)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_72/b)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_73/a)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_73/b)
.probe tran v(bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_0/clk)
.probe tran v(bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_0/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_0_VCC)
.probe tran v(bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_1/clk)
.probe tran v(bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_1/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_1_VCC)
.probe tran v(bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_2/clk)
.probe tran v(bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_2/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_2_VCC)
.probe tran v(bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_3/clk)
.probe tran v(bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_3/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_3_VCC)
.probe tran v(bzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift/clk)
.probe tran v(bzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__69/clk)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__69/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__69_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__70/clk)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__70/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__70_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__72/clk)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__72/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__72_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__74/clk)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__74/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__74_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__77/clk)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__77/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__77_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__78/clk)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__78/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__78_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__81/clk)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__81/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__81_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__82/clk)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__82/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4engclkpin__82_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/myflop4engclkpin__70/clk)
.probe tran v(right_stack_inst/mgtile_inst3/myflop4engclkpin__70/d)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_buf_cell/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_buf_cell/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_buf_cell_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_0/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_0/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_0_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_1/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_1/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_1_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_2/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_2/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_2_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_3/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_3/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_3_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_buf_cell/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_buf_cell/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_buf_cell_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_0/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_0/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_0_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_1/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_1/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_1_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_2/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_2/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_2_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_3/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_3/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_3_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_4/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_4/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_4_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_5/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_5/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_5_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_6/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_6/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_6_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_buf_cell/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_buf_cell/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_buf_cell_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_0/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_0/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_0_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_1/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_1/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_1_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_2/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_2/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_2_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_3/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_3/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_3_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_4/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_4/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_4_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_5/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_5/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_5_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_6/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_6/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_6_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_buf_cell/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_buf_cell/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_buf_cell_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_0/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_0/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_0_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_1/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_1/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_1_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_2/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_2/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_2_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_3/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_3/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_3_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_4/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_4/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_4_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_5/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_5/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_5_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_6/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_6/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_6_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_buf_cell/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_buf_cell/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_buf_cell_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_0/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_0/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_0_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_1/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_1/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_10/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_10/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_10_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_11/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_11/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_11_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_12/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_12/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_12_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_13/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_13/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_13_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_14/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_14/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_14_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_15/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_15/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_15_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_1_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_2/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_2/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_2_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_3/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_3/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_3_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_4/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_4/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_4_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_5/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_5/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_5_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_6/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_6/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_6_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_7/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_7/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_7_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_8/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_8/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_8_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_9/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_9/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_9_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_3/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_3/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_3_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_0/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_0/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_0_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_1/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_1/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_1_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_2/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_2/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_2_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_3/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_3/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_3_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_4/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_4/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_4_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_5/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_5/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_5_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_6/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_6/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_6_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_7/clk)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_7/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_7_VCC)
.probe tran v(right_stack_inst/mgtile_inst3/sch_wrapper_eng_clk_RT_inv_cell_2lvl_0/clk)
.probe tran v(right_stack_inst/mgtile_inst3/sch_wrapper_eng_clk_RT_inv_cell_2lvl_0/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/sch_wrapper_eng_clk_RT_inv_cell_2lvl_0_VCC)
.probe tran v(right_stack_inst/mybuff4engclkpin__84/clk)
.probe tran v(right_stack_inst/mybuff4engclkpin__84/clkout)
.probe tran v(right_stack_inst/mybuff4engclkpin__84_VCC)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_0/clk)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_0/clkout)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_0_VCC)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_1/clk)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_1/clkout)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_10/clk)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_10/clkout)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_10_VCC)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_11/clk)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_11/clkout)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_11_VCC)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_12/clk)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_12/clkout)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_12_VCC)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_13/clk)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_13/clkout)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_13_VCC)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_14/clk)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_14/clkout)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_14_VCC)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_15/clk)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_15/clkout)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_15_VCC)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_1_VCC)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_2/clk)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_2/clkout)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_2_VCC)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_3/clk)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_3/clkout)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_3_VCC)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_4/clk)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_4/clkout)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_4_VCC)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_5/clk)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_5/clkout)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_5_VCC)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_6/clk)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_6/clkout)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_6_VCC)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_7/clk)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_7/clkout)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_7_VCC)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_8/clk)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_8/clkout)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_8_VCC)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_9/clk)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_9/clkout)
.probe tran v(spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_9_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_0/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_0/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_0_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_1/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_1/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_10/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_10/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_10_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_11/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_11/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_11_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_12/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_12/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_12_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_13/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_13/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_13_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_14/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_14/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_14_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_15/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_15/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_15_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_16/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_16/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_16_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_17/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_17/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_17_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_18/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_18/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_18_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_19/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_19/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_19_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_1_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_2/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_2/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_20/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_20/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_20_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_21/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_21/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_21_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_22/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_22/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_22_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_23/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_23/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_23_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_2_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_3/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_3/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_3_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_4/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_4/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_4_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_5/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_5/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_5_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_6/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_6/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_6_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_7/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_7/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_7_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_8/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_8/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_8_VCC)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_9/clk)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_9/clkout)
.probe tran v(spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_9_VCC)
.probe tran v(spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_0/clk)
.probe tran v(spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_0/clkout)
.probe tran v(spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_0_VCC)
.probe tran v(spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_1/clk)
.probe tran v(spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_1/clkout)
.probe tran v(spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_1_VCC)
.probe tran v(spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_2/clk)
.probe tran v(spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_2/clkout)
.probe tran v(spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_2_VCC)
.probe tran v(u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_0_lvl_spine2lstack_engclk_ctech_lvlshift/clk)
.probe tran v(u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_0_lvl_spine2lstack_engclk_ctech_lvlshift/clkout)
.probe tran v(u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_1_lvl_spine2lstack_engclk_ctech_lvlshift/clk)
.probe tran v(u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_1_lvl_spine2lstack_engclk_ctech_lvlshift/clkout)
.probe tran v(u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_2_lvl_spine2lstack_engclk_ctech_lvlshift/clk)
.probe tran v(u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_2_lvl_spine2lstack_engclk_ctech_lvlshift/clkout)
.probe tran v(u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_3_lvl_spine2lstack_engclk_ctech_lvlshift/clk)
.probe tran v(u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_3_lvl_spine2lstack_engclk_ctech_lvlshift/clkout)
.probe tran v(xbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_2to1)
.probe tran v(xbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1)
.probe tran v(xbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1_C_SPC0)
.probe tran v(xbzmnotchwrap/bzmnotch/bzmpll_inst0/ctmi_225)
.probe tran v(xbzmnotchwrap/bzmnotch/bzmpll_inst0/fast_clk_count_reg_0)
.probe tran v(xbzmnotchwrap/bzmnotch/bzmpll_inst0/pll_fast_clk_by2_reg)
.probe tran v(xbzmnotchwrap/bzmnotch/bzmpll_inst0/pwc_clk_gate_fast_clk_count_reg_1)
.probe tran v(xbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_57)
.probe tran v(xbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_58)
.probe tran v(xbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67)
.probe tran v(xbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67_2inv_eco_cell)
.probe tran v(xbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_72)
.probe tran v(xbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_73)
.probe tran v(xbzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_0)
.probe tran v(xbzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_1)
.probe tran v(xbzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_2)
.probe tran v(xbzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_3)
.probe tran v(xbzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift)
.probe tran v(xright_stack_inst/mgtile_inst3/mybuff4engclkpin__69)
.probe tran v(xright_stack_inst/mgtile_inst3/mybuff4engclkpin__70)
.probe tran v(xright_stack_inst/mgtile_inst3/mybuff4engclkpin__72)
.probe tran v(xright_stack_inst/mgtile_inst3/mybuff4engclkpin__74)
.probe tran v(xright_stack_inst/mgtile_inst3/mybuff4engclkpin__77)
.probe tran v(xright_stack_inst/mgtile_inst3/mybuff4engclkpin__78)
.probe tran v(xright_stack_inst/mgtile_inst3/mybuff4engclkpin__81)
.probe tran v(xright_stack_inst/mgtile_inst3/mybuff4engclkpin__82)
.probe tran v(xright_stack_inst/mgtile_inst3/myflop4engclkpin__70)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_buf_cell)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_0)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_1)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_2)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_3)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_buf_cell)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_0)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_1)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_2)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_3)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_4)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_5)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_6)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_buf_cell)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_0)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_1)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_2)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_3)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_4)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_5)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_6)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_buf_cell)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_0)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_1)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_2)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_3)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_4)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_5)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_6)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_buf_cell)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_0)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_1)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_10)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_11)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_12)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_13)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_14)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_15)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_2)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_3)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_4)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_5)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_6)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_7)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_8)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_9)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_3)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_0)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_1)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_2)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_3)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_4)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_5)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_6)
.probe tran v(xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_7)
.probe tran v(xright_stack_inst/mgtile_inst3/sch_wrapper_eng_clk_RT_inv_cell_2lvl_0)
.probe tran v(xright_stack_inst/mybuff4engclkpin__84)
.probe tran v(xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_0)
.probe tran v(xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_1)
.probe tran v(xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_10)
.probe tran v(xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_11)
.probe tran v(xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_12)
.probe tran v(xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_13)
.probe tran v(xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_14)
.probe tran v(xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_15)
.probe tran v(xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_2)
.probe tran v(xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_3)
.probe tran v(xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_4)
.probe tran v(xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_5)
.probe tran v(xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_6)
.probe tran v(xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_7)
.probe tran v(xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_8)
.probe tran v(xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_9)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_0)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_1)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_10)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_11)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_12)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_13)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_14)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_15)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_16)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_17)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_18)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_19)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_2)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_20)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_21)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_22)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_23)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_3)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_4)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_5)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_6)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_7)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_8)
.probe tran v(xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_9)
.probe tran v(xspinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_0)
.probe tran v(xspinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_1)
.probe tran v(xspinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_2)
.probe tran v(xu_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_0_lvl_spine2lstack_engclk_ctech_lvlshift)
.probe tran v(xu_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_1_lvl_spine2lstack_engclk_ctech_lvlshift)
.probe tran v(xu_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_2_lvl_spine2lstack_engclk_ctech_lvlshift)
.probe tran v(xu_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_3_lvl_spine2lstack_engclk_ctech_lvlshift)
