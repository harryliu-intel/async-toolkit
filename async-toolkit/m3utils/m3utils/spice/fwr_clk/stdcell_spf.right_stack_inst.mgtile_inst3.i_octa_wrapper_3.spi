.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/ds1_ulvt/spf/lib783_i0s_160h_50pp_ds1_ulvt_100c_tttt_cmax/i0sbfn000qa1d48x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/supbase_lvt/spf/lib783_i0s_160h_50pp_supbase_lvt_100c_tttt_cmax/i0sinv030tb1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/supbase_ulvt/spf/lib783_i0s_160h_50pp_supbase_ulvt_100c_tttt_cmax/i0sinv000ta1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sao0022ab1n06x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0srm0023aa1d03x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/dsiseq_lvt/spf/lib783_i0s_160h_50pp_dsiseq_lvt_100c_tttt_cmax/i0sfkn400ab1q03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/seq_ulvt/spf/lib783_i0s_160h_50pp_seq_ulvt_100c_tttt_cmax/i0sfvz203aa1d02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0saoai13ab1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/ds1_ulvt/spf/lib783_i0s_160h_50pp_ds1_ulvt_100c_tttt_cmax/i0sbfn000qa1n12x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/spcl_ulvt/spf/lib783_i0s_160h_50pp_spcl_ulvt_100c_tttt_cmax/i0stilo00aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sinv030aa1n10x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sbfn000aa1n21x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0smkn022aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0snand02aa1n04x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/dsicore_ulvt/spf/lib783_i0s_160h_50pp_dsicore_ulvt_100c_tttt_cmax/i0sinv000ra1n09x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/ldrsupbase_ulvt/spf/lib783_i0s_160h_50pp_ldrsupbase_ulvt_100c_tttt_cmax/i0snanp04aa1n01x1.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/supbase_ulvt/spf/lib783_i0s_160h_50pp_supbase_ulvt_100c_tttt_cmax/i0sinv000ta1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/ldrsupbase_lvt/spf/lib783_i0s_160h_50pp_ldrsupbase_lvt_100c_tttt_cmax/i0saoix22ab1d01x1.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sinv040aa1n16x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/dsiseq_lvt/spf/lib783_i0s_160h_50pp_dsiseq_lvt_100c_tttt_cmax/i0sfan018ab1d03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/supbase_ulvt/spf/lib783_i0s_160h_50pp_supbase_ulvt_100c_tttt_cmax/i0sinv030ta1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0snanb02aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0src0022ab1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0soai122ab1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0saoai13ab1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/ds1_ulvt/spf/lib783_i0s_160h_50pp_ds1_ulvt_100c_tttt_cmax/i0sbfn000qa1n36x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sbfn000aa1d48x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/supbase_ulvt/spf/lib783_i0s_160h_50pp_supbase_ulvt_100c_tttt_cmax/i0saoix22aa1d02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0snand02ab1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0saoai13aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sinv000ab1n09x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n06x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sinv000aa1n18x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0saoi013aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/dsiseq_lvt/spf/lib783_i0s_160h_50pp_dsiseq_lvt_100c_tttt_cmax/i0sfan018ab1d02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sbfn000aa1n12x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/ds1_ulvt/spf/lib783_i0s_160h_50pp_ds1_ulvt_100c_tttt_cmax/i0snorp02qa1n06x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0smbn022aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0snand03aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sbfn000aa1n04x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/ldrsupbase_ulvt/spf/lib783_i0s_160h_50pp_ldrsupbase_ulvt_100c_tttt_cmax/i0saoix22aa1d01x1.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/dsiseq_ulvt/spf/lib783_i0s_160h_50pp_dsiseq_ulvt_100c_tttt_cmax/i0sfan018aa1d03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/seq_lvt/spf/lib783_i0s_160h_50pp_seq_lvt_100c_tttt_cmax/i0sfvz803ab1q03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0snor002aa1n04x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sbfn000ab1n06x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0soai013aa1n03x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/edrseq_lvt/spf/lib783_i0s_160h_50pp_edrseq_lvt_100c_tttt_cmax/i0sfvz803ab1q03x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0soab012ab1n02x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0saoai13aa1n02x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sand002ab1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/dsicore_ulvt/spf/lib783_i0s_160h_50pp_dsicore_ulvt_100c_tttt_cmax/i0smdna82aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/dsiobsolete_ulvt/spf/lib783_i0s_160h_50pp_dsiobsolete_ulvt_100c_tttt_cmax/i0sfaz003ca1d03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0saoi222aa1n06x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sinv040aa1d32x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sinv000aa1n09x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sbfn000aa1n36x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0snor002ab1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/seq_lvt/spf/lib783_i0s_160h_50pp_seq_lvt_100c_tttt_cmax/i0sfvz803ab1q02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n12x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0snorp03ab1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sinv000aa1n24x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sand003aa1n03x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/ds1_ulvt/spf/lib783_i0s_160h_50pp_ds1_ulvt_100c_tttt_cmax/i0sinv000qa1n30x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0soai013aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sinv000aa1d42x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/supbase_lvt/spf/lib783_i0s_160h_50pp_supbase_lvt_100c_tttt_cmax/i0snand04ab1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0snor003aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sand002ab1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/dsicore_ulvt/spf/lib783_i0s_160h_50pp_dsicore_ulvt_100c_tttt_cmax/i0sinv000ra1n06x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/ds1_ulvt/spf/lib783_i0s_160h_50pp_ds1_ulvt_100c_tttt_cmax/i0sbfn000qa1n18x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0soaoi13ab1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/supbase_ulvt/spf/lib783_i0s_160h_50pp_supbase_ulvt_100c_tttt_cmax/i0sinv020ta1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sbfn000aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/ldrseq_lvt/spf/lib783_i0s_160h_50pp_ldrseq_lvt_100c_tttt_cmax/i0sfvz803ab1q01x1.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sinv030aa1n08x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sbfn000ab1n12x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sao0022aa1n03x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0smbn022ab1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0snor002aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sbfn000ab1n04x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sinv000ab1n06x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sinv000aa1n15x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/seq_lvt/spf/lib783_i0s_160h_50pp_seq_lvt_100c_tttt_cmax/i0sfvz403ab1q03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0snanp02ab1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/supbase_ulvt/spf/lib783_i0s_160h_50pp_supbase_ulvt_100c_tttt_cmax/i0snand04aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/seq_lvt/spf/lib783_i0s_160h_50pp_seq_lvt_100c_tttt_cmax/i0sfun480ab1q03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scbf000aa1n18x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scilb05aa1n04x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sand002aa1n02x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sinv000aa1n30x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/dsicore_ulvt/spf/lib783_i0s_160h_50pp_dsicore_ulvt_100c_tttt_cmax/i0sinv000ra1n12x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sbfn000ab1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sbfn000aa1n18x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sxnrc02aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0snano22aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0snanp03aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0saoib12ab1n04x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/seq_ulvt/spf/lib783_i0s_160h_50pp_seq_ulvt_100c_tttt_cmax/i0sfvn003aa1d03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0snona23aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/ds1_ulvt/spf/lib783_i0s_160h_50pp_ds1_ulvt_100c_tttt_cmax/i0sbfn000qa1d42x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0soai112aa1n02x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_lvt/spf/lib783_i0s_160h_50pp_clk_lvt_100c_tttt_cmax/i0scilb05ab1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/dsilvl_ulvt/spf/lib783_i0s_160h_50pp_dsilvl_ulvt_100c_tttt_cmax/i0ssgc0ndaa1d06x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sinv000aa1n06x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0snona22ab1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sinv040aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/seq_ulvt/spf/lib783_i0s_160h_50pp_seq_ulvt_100c_tttt_cmax/i0sfvz403aa1q03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/dsicore_lvt/spf/lib783_i0s_160h_50pp_dsicore_lvt_100c_tttt_cmax/i0smdna82ab1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sinv030aa1n06x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scilb05aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0smtn022aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0snanp02aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0soaoi13aa1n02x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sinv000aa1n21x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sbfn000ab1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sbfm604ab1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/supbase_ulvt/spf/lib783_i0s_160h_50pp_supbase_ulvt_100c_tttt_cmax/i0sand004aa1n03x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sinv000ab1n04x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sbfn000aa1n09x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sbfm807ab1n04x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0smbn022ab1n09x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0soao003aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/dsiseq_lvt/spf/lib783_i0s_160h_50pp_dsiseq_lvt_100c_tttt_cmax/i0sfan003ab1d02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/ldrclk_ulvt/spf/lib783_i0s_160h_50pp_ldrclk_ulvt_100c_tttt_cmax/i0scilb05aa1n02x1.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n18x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/dsicore_ulvt/spf/lib783_i0s_160h_50pp_dsicore_ulvt_100c_tttt_cmax/i0smdna22aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0snanb02ab1n09x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0soai022aa1n02x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sbfm402ab1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sbfn000aa1n24x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/ds1_ulvt/spf/lib783_i0s_160h_50pp_ds1_ulvt_100c_tttt_cmax/i0sbfn000qa1n30x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0snona22aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sbfm201ab1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/supbase_ulvt/spf/lib783_i0s_160h_50pp_supbase_ulvt_100c_tttt_cmax/i0sand004aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0snand43ab1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sbfn000aa1d42x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/dsiseq_lvt/spf/lib783_i0s_160h_50pp_dsiseq_lvt_100c_tttt_cmax/i0sfan018ab1d06x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/supbase_lvt/spf/lib783_i0s_160h_50pp_supbase_lvt_100c_tttt_cmax/i0saoix22ab1d04x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sinv000aa1n12x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/supbase_lvt/spf/lib783_i0s_160h_50pp_supbase_lvt_100c_tttt_cmax/i0sbfm201tb1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/ldrsupbase_lvt/spf/lib783_i0s_160h_50pp_ldrsupbase_lvt_100c_tttt_cmax/i0sbfm403tb1n01x1.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sbfn000ab1n18x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sinv000aa1n04x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/seq_lvt/spf/lib783_i0s_160h_50pp_seq_lvt_100c_tttt_cmax/i0sfvn003ab1d03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/supbase_lvt/spf/lib783_i0s_160h_50pp_supbase_lvt_100c_tttt_cmax/i0sinv000tb1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0snorb03aa1n03x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sinv030aa1n04x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0srm0023ab1d03x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/supbase_ulvt/spf/lib783_i0s_160h_50pp_supbase_ulvt_100c_tttt_cmax/i0saoi023aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/seq_lvt/spf/lib783_i0s_160h_50pp_seq_lvt_100c_tttt_cmax/i0sfvz203ab1d02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/ldrsupbase_lvt/spf/lib783_i0s_160h_50pp_ldrsupbase_lvt_100c_tttt_cmax/i0sbfm201tb1n01x1.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scilb05aa1n18x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sinv000ab1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sbfm807ab1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/seq_ulvt/spf/lib783_i0s_160h_50pp_seq_ulvt_100c_tttt_cmax/i0sfvz203aa1d03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0smkn022ab1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/supbase_ulvt/spf/lib783_i0s_160h_50pp_supbase_ulvt_100c_tttt_cmax/i0saoix22aa1d04x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/supbase_lvt/spf/lib783_i0s_160h_50pp_supbase_lvt_100c_tttt_cmax/i0sinv000tb1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sbfn000aa1n30x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0sbfn000ab1n09x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_lvt/spf/lib783_i0s_160h_50pp_base_lvt_100c_tttt_cmax/i0srm0023ab1d02x5.spf"
.include "/nfs/site/disks/zsc9_fwr_sd_001/mostafab/PESG_char_test2/xtract/netlists/polo/i0ssgdn0gaa1d12x5/i0ssgdn0gaa1d12x5_100C_pcss.spf"
.include "/nfs/site/disks/zsc9_fwr_sd_001/mostafab/PESG_char_test2/xtract/netlists/polo/i0ssgstndaa1d30x5/i0ssgstndaa1d30x5_100C_pcss.spf"
.include "/nfs/site/disks/zsc9_fwr_sd_001/mostafab/PESG_char_test2/xtract/netlists/polo/i0ssgckndaa1d18x5/i0ssgckndaa1d18x5_100C_pcss.spf"
.include "/nfs/site/disks/zsc9_fwr_sd_001/mostafab/PESG_char_test2/xtract/netlists/polo/i0ssgdn0paa1d12x5/i0ssgdn0paa1d12x5_100C_pcss.spf"
*.include "/nfs/site/disks/zsc9_fwr_sd_004/sjammala/COLLATERALS/latest/hips/adpllg6/sp/adpllg6.sp"
.include "/nfs/site/disks/zsc9_fwr_lib_char_001/mostafab/fwr_timing/adpllg6.sp"
.include "/nfs/site/disks/zsc9_fwr_sd_004/sjammala/COLLATERALS/latest/hips/tce_top_wrapper/sp/tce_top_wrapper.sp"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/supclk_ulvt/spf/lib783_i0s_160h_50pp_supclk_ulvt_100c_tttt_cmax/i0scbf026aa1n06x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0s_160h_50pp_base_ulvt_100c_tttt_cmax/i0sinv030aa1n02x5.spf"
