vright_stack_inst/mgtile_inst3/clk_net_3_rt_mgtile_6_9_right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9/clkout	right_stack_inst/mgtile_inst3/clk_net_3_rt_mgtile_6_9	right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9/clkout	0
vright_stack_inst/mgtile_inst3/clk_net_3_rt_mgtile_6_9_right_stack_inst/mgtile_inst3/my_flop/clk	right_stack_inst/mgtile_inst3/clk_net_3_rt_mgtile_6_9	right_stack_inst/mgtile_inst3/my_flop/clk	0
vright_stack_inst/mgtile_inst3/clk_net_3_rt_mgtile_6_9_right_stack_inst/mgtile_inst3/U43/clk	right_stack_inst/mgtile_inst3/clk_net_3_rt_mgtile_6_9	right_stack_inst/mgtile_inst3/U43/clk	0
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_vcc bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140569_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140569_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140568_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140568_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124089_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124089_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/bzmpll_inst0/clock_opt_cts_ZCTSINV_745_138433_vcc bzmnotchwrap/bzmnotch/bzmpll_inst0/clock_opt_cts_ZCTSINV_745_138433_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/clock_opt_cts_engclk_i_vtd123961_vcc bzmnotchwrap/bzmnotch/notch_dcc_inst0/clock_opt_cts_engclk_i_vtd123961_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux_vcc bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani_vcc bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_391_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_391_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_390_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_390_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_389_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_389_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_388_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_388_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_387_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_387_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_386_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_386_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_355_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_355_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_385_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_385_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_384_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_384_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_383_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_383_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_382_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_382_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_381_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_381_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_380_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_380_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_379_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_379_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_378_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_378_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_377_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_377_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_356_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_356_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_376_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_376_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_375_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_375_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_374_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_374_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_373_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_373_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_372_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_372_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_371_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_371_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_370_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_370_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_369_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_369_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_359_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_359_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_368_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_368_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_367_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_367_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_366_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_366_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_365_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_365_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_364_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_364_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_363_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_363_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_362_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_362_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_361_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_361_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_360_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_360_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_vcc_in bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_VCC_IN 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_vcc_out bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_VCC_OUT 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_497_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_497_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_rt_3_sch_vcc right_stack_inst/mgtile_inst3/clk_buf_rt_3_sch_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_496_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_496_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_495_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_495_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_494_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_494_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_493_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_493_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_492_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_492_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_491_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_491_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_490_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_490_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_489_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_489_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_488_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_488_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_487_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_487_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_486_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_486_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_485_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_485_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_484_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_484_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_483_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_483_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_482_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_482_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_481_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_481_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_480_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_480_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_479_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_479_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_478_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_478_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_477_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_477_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_476_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_476_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_475_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_475_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_474_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_474_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_473_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_473_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_472_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_472_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_471_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_471_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_470_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_470_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_469_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_469_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_468_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_468_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_467_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_467_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_466_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_466_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_465_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_465_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_464_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_464_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_463_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_463_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_462_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_462_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_461_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_461_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_460_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_460_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_459_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_459_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_458_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_458_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_457_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_457_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_456_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_456_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_455_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_455_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_454_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_454_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_453_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_453_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_452_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_452_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_451_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_451_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_450_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_450_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_449_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_449_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_448_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_448_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_447_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_447_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_446_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_446_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_445_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_445_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9_VCC 0 vminer
vright_stack_inst/mgtile_inst3/my_flop_vcc right_stack_inst/mgtile_inst3/my_flop_VCC 0 vminer
vright_stack_inst/mgtile_inst3/U43_vcc right_stack_inst/mgtile_inst3/U43_VCC 0 vminer
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/clk1	bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/clk1	0	0
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/s	bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/s	0	0
vbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clk1	bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clk1	0	vtrue
vbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/s	bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/s	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/en	bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/en	0	vtrue
vbzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/te	bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/te	0	0
vright_stack_inst/mgtile_inst3/my_flop/d	right_stack_inst/mgtile_inst3/my_flop/d	0	0
vright_stack_inst/mgtile_inst3/my_flop/rb	right_stack_inst/mgtile_inst3/my_flop/rb	0	0
