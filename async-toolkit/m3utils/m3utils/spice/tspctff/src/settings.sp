Vf0_0 f0_0 0 DC=0 PWL 0 0
Vf1_0 f1_0 0 DC=0 PWL 0 0
Vf2_0 f2_0 0 DC=0 PWL 0 0
Vf3_0 f3_0 0 DC=0 PWL 0 0
Vf0_1 f0_1 0 DC=0 PWL 0 0
Vf1_1 f1_1 0 DC=0 PWL 0 0
Vf2_1 f2_1 0 DC=0 PWL 0 0
Vf3_1 f3_1 0 DC=0 PWL 0 0
Vf0_2 f0_2 0 DC=0 PWL 0 0
Vf1_2 f1_2 0 DC=0 PWL 0 0
Vf2_2 f2_2 0 DC=0 PWL 0 0
Vf3_2 f3_2 0 DC=0 PWL 0 0
Vf0_3 f0_3 0 DC=0 PWL 0 0
Vf1_3 f1_3 0 DC=0 PWL 0 0
Vf2_3 f2_3 0 DC=0 PWL 0 0
Vf3_3 f3_3 0 DC=0 PWL 0 0
Vf0_4 f0_4 0 DC=0 PWL 0 0
Vf1_4 f1_4 0 DC=0 PWL 0 0
Vf2_4 f2_4 0 DC=0 PWL 0 0
Vf3_4 f3_4 0 DC=0 PWL 0 0
Vf0_5 f0_5 0 DC=0 PWL 0 0
Vf1_5 f1_5 0 DC=0 PWL 0 0
Vf2_5 f2_5 0 DC=0 PWL 0 0
Vf3_5 f3_5 0 DC=0 PWL 0 0
Vf0_6 f0_6 0 DC=0 PWL 0 0
Vf1_6 f1_6 0 DC=0 PWL 0 0
Vf2_6 f2_6 0 DC=0 PWL 0 0
Vf3_6 f3_6 0 DC=0 PWL 0 0
Vf0_7 f0_7 0 DC=0 PWL 0 0
Vf1_7 f1_7 0 DC=0 PWL 0 0
Vf2_7 f2_7 0 DC=0 PWL 0 0
Vf3_7 f3_7 0 DC=0 PWL 0 0
