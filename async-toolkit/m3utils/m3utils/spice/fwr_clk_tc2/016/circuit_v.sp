vright_stack_inst/mgtile_inst3/clk_net_3_rt_mgtile_6_9_right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9/clkout	right_stack_inst/mgtile_inst3/clk_net_3_rt_mgtile_6_9	right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9/clkout	0
vright_stack_inst/mgtile_inst3/clk_net_3_rt_mgtile_6_9_right_stack_inst/mgtile_inst3/my_flop/clk	right_stack_inst/mgtile_inst3/clk_net_3_rt_mgtile_6_9	right_stack_inst/mgtile_inst3/my_flop/clk	0
vright_stack_inst/mgtile_inst3/clk_net_3_rt_mgtile_6_9_right_stack_inst/mgtile_inst3/U15/clk	right_stack_inst/mgtile_inst3/clk_net_3_rt_mgtile_6_9	right_stack_inst/mgtile_inst3/U15/clk	0
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_vcc bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140569_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140569_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140568_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140568_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124089_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124089_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/bzmpll_inst0/clock_opt_cts_ZCTSINV_745_138433_vcc bzmnotchwrap/bzmnotch/bzmpll_inst0/clock_opt_cts_ZCTSINV_745_138433_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/clock_opt_cts_engclk_i_vtd123961_vcc bzmnotchwrap/bzmnotch/notch_dcc_inst0/clock_opt_cts_engclk_i_vtd123961_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux_vcc bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani_vcc bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_eng_rt_focal_buf_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_eng_rt_focal_buf_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2318_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2318_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2317_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2317_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2316_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2316_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2315_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2315_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2314_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2314_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2313_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2313_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2282_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2282_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2312_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2312_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2311_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2311_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2310_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2310_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2309_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2309_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2308_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2308_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2307_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2307_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2306_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2306_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2305_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2305_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2304_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2304_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2283_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2283_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2303_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2303_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2302_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2302_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2301_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2301_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2300_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2300_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2299_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2299_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2298_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2298_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2297_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2297_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2296_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2296_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2286_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2286_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2295_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2295_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2294_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2294_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2293_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2293_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2292_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2292_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2291_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2291_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2290_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2290_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2289_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2289_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2288_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2288_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2287_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2287_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_vcc_in bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_VCC_IN 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_vcc_out bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_VCC_OUT 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2371_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2371_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2370_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2370_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_rt_3_sch_vcc right_stack_inst/mgtile_inst3/clk_buf_rt_3_sch_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2369_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2369_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2368_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2368_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2367_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2367_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2366_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2366_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2365_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2365_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2364_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2364_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2363_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2363_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2362_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2362_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2361_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2361_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2360_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2360_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2359_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2359_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2358_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2358_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2357_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2357_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2356_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2356_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2355_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2355_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2354_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2354_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2353_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2353_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2352_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2352_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2351_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2351_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2350_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2350_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2349_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2349_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2348_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2348_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2347_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2347_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2346_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2346_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2345_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2345_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2344_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2344_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2343_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2343_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2342_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2342_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2341_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2341_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2340_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2340_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2339_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2339_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2338_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2338_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2337_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2337_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2336_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2336_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2335_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2335_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2334_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2334_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2333_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2333_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2332_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2332_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2331_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2331_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2330_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2330_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2329_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2329_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2328_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2328_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2327_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2327_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2326_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2326_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2325_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2325_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2324_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2324_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2323_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2323_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2322_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2322_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2321_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2321_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2320_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2320_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_2319_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_2319_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9_VCC 0 vminer
vright_stack_inst/mgtile_inst3/my_flop_vcc right_stack_inst/mgtile_inst3/my_flop_VCC 0 vminer
vright_stack_inst/mgtile_inst3/U15_vcc right_stack_inst/mgtile_inst3/U15_VCC 0 vminer
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/clk1	bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/clk1	0	0
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/s	bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/s	0	0
vbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clk1	bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clk1	0	vtrue
vbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/s	bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/s	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/en	bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/en	0	vtrue
vbzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/te	bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/te	0	0
vright_stack_inst/mgtile_inst3/my_flop/d	right_stack_inst/mgtile_inst3/my_flop/d	0	0
vright_stack_inst/mgtile_inst3/my_flop/rb	right_stack_inst/mgtile_inst3/my_flop/rb	0	0
