.INCLUDE 'my_devices.spi'
.INCLUDE 'tphn7_18gpio.spi'
