.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scbf000aa1d36x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scbf000aa1n12x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scilb05aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1d24x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1d24x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n24x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1d30x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n04x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n12x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scmbn22aa1n02x5.spf"
.include "/nfs/site/disks/zsc9_fwr_sd_001/mostafab/PESG_char_test2/xtract/netlists/polo/i0ssgstndaa1d30x5/i0ssgstndaa1d30x5_100C_pcss.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/seq_ulvt/spf/lib783_i0s_160h_50pp_seq_ulvt_100c_tttt_cmax/i0sfvn003aa1d02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/seq_ulvt/spf/lib783_i0s_160h_50pp_seq_ulvt_100c_tttt_cmax/i0sfvn003aa1d03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1d04x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1d04x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1d06x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1d06x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1d24x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1d24x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1d30x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1d30x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1d36x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1d36x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1d42x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1d42x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1d48x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1d48x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n02x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n03x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n04x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n04x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n06x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n06x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n09x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n09x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n12x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n12x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n15x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n15x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n18x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n18x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n24x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n24x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n30x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n30x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n36x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/clk_ulvt/spf/lib783_i0s_160h_50pp_clk_ulvt_100c_tttt_cmax/i0scinv00aa1n36x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0s_160h_50pp/pdk080_r4v2p0_efv/dsiseq_lvt/spf/lib783_i0s_160h_50pp_dsiseq_lvt_100c_tttt_cmax/i0sfan018ab1d06x5.spf"
