.include '/nfs/site/disks/zsc3_fon_fe_0001/mnystroe/BTC4/BTC4/g1i_extracted.hspice'

.include '/nfs/site/disks/zsc3_fon_fe_0001/mnystroe/BTC4/BTC4/cell.hspice'
