xbzmnotchwrap/bzmnotch/bzmpll_inst0/pll_fast_clk_by2_reg bzmnotchwrap/bzmnotch/bzmpll_inst0/pll_fast_clk_by2_reg/clk bzmnotchwrap/bzmnotch/bzmpll_inst0/pll_fast_clk_by2_reg/d bzmnotchwrap/bzmnotch/bzmpll_inst0/pll_fast_clk_by2_reg/o bzmnotchwrap/bzmnotch/bzmpll_inst0/pll_fast_clk_by2_reg/rb
xbzmnotchwrap/bzmnotch/bzmpll_inst0/ctmi_225 bzmnotchwrap/bzmnotch/bzmpll_inst0/ctmi_225/a bzmnotchwrap/bzmnotch/bzmpll_inst0/ctmi_225/o1 bzmnotchwrap/bzmnotch/bzmpll_inst0/ctmi_225_VCC VSSX i0sinv030ta1n02x5
xbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1 bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1/a bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1/b bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1/o bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1/sa
xbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1_C_SPC0 bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1_C_SPC0/a bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1_C_SPC0/b bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1_C_SPC0/o bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1_C_SPC0/sa
xbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_2to1 bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_2to1/a bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_2to1/b bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_2to1/o bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_2to1/sa
xbzmnotchwrap/bzmnotch/bzmpll_inst0/fast_clk_count_reg_0 bzmnotchwrap/bzmnotch/bzmpll_inst0/fast_clk_count_reg_0/clk bzmnotchwrap/bzmnotch/bzmpll_inst0/fast_clk_count_reg_0/d bzmnotchwrap/bzmnotch/bzmpll_inst0/fast_clk_count_reg_0/o bzmnotchwrap/bzmnotch/bzmpll_inst0/fast_clk_count_reg_0/rb
xbzmnotchwrap/bzmnotch/bzmpll_inst0/pwc_clk_gate_fast_clk_count_reg_1 bzmnotchwrap/bzmnotch/bzmpll_inst0/pwc_clk_gate_fast_clk_count_reg_1/clk bzmnotchwrap/bzmnotch/bzmpll_inst0/pwc_clk_gate_fast_clk_count_reg_1/clkout bzmnotchwrap/bzmnotch/bzmpll_inst0/pwc_clk_gate_fast_clk_count_reg_1/en bzmnotchwrap/bzmnotch/bzmpll_inst0/pwc_clk_gate_fast_clk_count_reg_1/te
xbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_72 bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_72/a bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_72/b bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_72/o1 bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_72_VCC
xbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_58 bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_58/clk bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_58/clkout bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_58_VCC VSSX i0scinv00aa1n18x5
xbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67 bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67/a bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67/b bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67/c bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67/d
xbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_73 bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_73/a bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_73/b bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_73/c bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_73/d
xbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_57 bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_57/a bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_57/b bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_57/c bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_57/out0
xbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67_2inv_eco_cell bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67_2inv_eco_cell/clk bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67_2inv_eco_cell/clkout bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67_2inv_eco_cell_VCC VSSX i0scinv00aa1n18x5
xbzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_0 bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_0/clk bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_0/clkout bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_0_VCC VSSX i0scinv00aa1n18x5
xbzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_1 bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_1/clk bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_1/clkout bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_1_VCC VSSX i0scinv00aa1n18x5
xbzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_2 bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_2/clk bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_2/clkout bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_2_VCC VSSX i0scinv00aa1n18x5
xbzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_3 bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_3/clk bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_3/clkout bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_3_VCC VSSX i0scinv00aa1n18x5
xbzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift bzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift/clk bzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift/clkout bzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift/gne1_vo bzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift/gns2_vo
xspinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_0 spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_0/clk spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_0/clkout spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_0_VCC VSSX i0scbf000aa1n18x5
xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_0 spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_0/clk spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_0/clkout spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_0_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_1 spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_1/clk spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_1/clkout spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_1_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_2 spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_2/clk spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_2/clkout spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_2_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_3 spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_3/clk spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_3/clkout spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_3_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_4 spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_4/clk spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_4/clkout spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_4_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_5 spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_5/clk spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_5/clkout spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_5_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_6 spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_6/clk spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_6/clkout spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_6_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_7 spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_7/clk spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_7/clkout spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_7_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_8 spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_8/clk spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_8/clkout spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_8_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_9 spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_9/clk spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_9/clkout spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_9_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_10 spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_10/clk spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_10/clkout spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_10_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_11 spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_11/clk spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_11/clkout spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_11_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_12 spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_12/clk spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_12/clkout spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_12_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_13 spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_13/clk spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_13/clkout spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_13_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_14 spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_14/clk spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_14/clkout spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_14_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_15 spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_15/clk spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_15/clkout spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_15_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_1 spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_1/clk spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_1/clkout spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_1_VCC VSSX i0scbf000aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_0 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_0/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_0/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_0_VCC VSSX i0scinv00aa1n18x5
xu_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_1_lvl_spine2lstack_engclk_ctech_lvlshift u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_1_lvl_spine2lstack_engclk_ctech_lvlshift/clk u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_1_lvl_spine2lstack_engclk_ctech_lvlshift/clkout u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_1_lvl_spine2lstack_engclk_ctech_lvlshift_VCC_IN u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_1_lvl_spine2lstack_engclk_ctech_lvlshift_VCC_OUT
xu_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_0_lvl_spine2lstack_engclk_ctech_lvlshift u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_0_lvl_spine2lstack_engclk_ctech_lvlshift/clk u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_0_lvl_spine2lstack_engclk_ctech_lvlshift/clkout u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_0_lvl_spine2lstack_engclk_ctech_lvlshift_VCC_IN u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_0_lvl_spine2lstack_engclk_ctech_lvlshift_VCC_OUT
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_1 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_1/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_1/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_1_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_2 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_2/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_2/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_2_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_3 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_3/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_3/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_3_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_4 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_4/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_4/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_4_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_5 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_5/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_5/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_5_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_6 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_6/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_6/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_6_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_7 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_7/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_7/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_7_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_8 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_8/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_8/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_8_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_9 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_9/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_9/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_9_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_10 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_10/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_10/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_10_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_11 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_11/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_11/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_11_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_12 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_12/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_12/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_12_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_13 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_13/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_13/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_13_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_14 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_14/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_14/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_14_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_15 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_15/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_15/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_15_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_16 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_16/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_16/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_16_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_17 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_17/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_17/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_17_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_18 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_18/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_18/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_18_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_19 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_19/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_19/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_19_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_20 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_20/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_20/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_20_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_21 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_21/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_21/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_21_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_22 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_22/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_22/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_22_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_23 spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_23/clk spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_23/clkout spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_23_VCC VSSX i0scinv00aa1n18x5
xspinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_2 spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_2/clk spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_2/clkout spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_2_VCC VSSX i0scbf000aa1n18x5
xu_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_3_lvl_spine2lstack_engclk_ctech_lvlshift u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_3_lvl_spine2lstack_engclk_ctech_lvlshift/clk u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_3_lvl_spine2lstack_engclk_ctech_lvlshift/clkout u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_3_lvl_spine2lstack_engclk_ctech_lvlshift_VCC_IN u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_3_lvl_spine2lstack_engclk_ctech_lvlshift_VCC_OUT
xu_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_2_lvl_spine2lstack_engclk_ctech_lvlshift u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_2_lvl_spine2lstack_engclk_ctech_lvlshift/clk u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_2_lvl_spine2lstack_engclk_ctech_lvlshift/clkout u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_2_lvl_spine2lstack_engclk_ctech_lvlshift_VCC_IN u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_2_lvl_spine2lstack_engclk_ctech_lvlshift_VCC_OUT
xright_stack_inst/mybuff4engclkpin__84 right_stack_inst/mybuff4engclkpin__84/clk right_stack_inst/mybuff4engclkpin__84/clkout right_stack_inst/mybuff4engclkpin__84_VCC VSSX i0scbf026aa1n06x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_0 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_0/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_0/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_0_VCC VSSX i0scinv00aa1n12x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_1 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_1/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_1/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_1_VCC VSSX i0scinv00aa1n12x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_2 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_2/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_2/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_2_VCC VSSX i0scinv00aa1n12x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_3 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_3/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_3/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_3_VCC VSSX i0scinv00aa1n12x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_4 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_4/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_4/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_4_VCC VSSX i0scinv00aa1n12x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_5 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_5/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_5/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_5_VCC VSSX i0scinv00aa1n12x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_6 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_6/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_6/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_6_VCC VSSX i0scinv00aa1n12x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_7 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_7/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_7/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_7_VCC VSSX i0scinv00aa1n12x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_8 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_8/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_8/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_8_VCC VSSX i0scinv00aa1n12x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_9 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_9/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_9/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_9_VCC VSSX i0scinv00aa1n12x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_10 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_10/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_10/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_10_VCC VSSX i0scinv00aa1n12x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_11 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_11/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_11/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_11_VCC VSSX i0scinv00aa1n12x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_12 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_12/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_12/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_12_VCC VSSX i0scinv00aa1n12x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_13 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_13/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_13/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_13_VCC VSSX i0scinv00aa1n12x5
xright_stack_inst/mgtile_inst3/sch_wrapper_eng_clk_RT_inv_cell_2lvl_0 right_stack_inst/mgtile_inst3/sch_wrapper_eng_clk_RT_inv_cell_2lvl_0/clk right_stack_inst/mgtile_inst3/sch_wrapper_eng_clk_RT_inv_cell_2lvl_0/clkout right_stack_inst/mgtile_inst3/sch_wrapper_eng_clk_RT_inv_cell_2lvl_0_VCC VSSX i0scinv00aa1n06x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_14 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_14/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_14/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_14_VCC VSSX i0scinv00aa1n12x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_15 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_15/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_15/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_15_VCC VSSX i0scinv00aa1n12x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_buf_cell right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_buf_cell/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_buf_cell/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_buf_cell_VCC VSSX i0scbf000aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_3 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_3/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_3/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_3_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_0 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_0/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_0/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_0_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_1 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_1/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_1/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_1_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_2 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_2/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_2/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_2_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_3 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_3/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_3/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_3_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_4 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_4/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_4/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_4_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_5 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_5/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_5/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_5_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_6 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_6/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_6/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_6_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_7 right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_7/clk right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_7/clkout right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_7_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_buf_cell right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_buf_cell/clk right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_buf_cell/clkout right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_buf_cell_VCC VSSX i0scbf000aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_3 right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_3/clk right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_3/clkout right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_3_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_2 right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_2/clk right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_2/clkout right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_2_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_1 right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_1/clk right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_1/clkout right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_1_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_0 right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_0/clk right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_0/clkout right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_0_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/mybuff4engclkpin__82 right_stack_inst/mgtile_inst3/mybuff4engclkpin__82/clk right_stack_inst/mgtile_inst3/mybuff4engclkpin__82/clkout right_stack_inst/mgtile_inst3/mybuff4engclkpin__82_VCC VSSX i0scbf026aa1n06x5
xright_stack_inst/mgtile_inst3/mybuff4engclkpin__81 right_stack_inst/mgtile_inst3/mybuff4engclkpin__81/clk right_stack_inst/mgtile_inst3/mybuff4engclkpin__81/clkout right_stack_inst/mgtile_inst3/mybuff4engclkpin__81_VCC VSSX i0scbf026aa1n06x5
xright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_buf_cell right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_buf_cell/clk right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_buf_cell/clkout right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_buf_cell_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_6 right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_6/clk right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_6/clkout right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_6_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_5 right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_5/clk right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_5/clkout right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_5_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_4 right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_4/clk right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_4/clkout right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_4_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_3 right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_3/clk right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_3/clkout right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_3_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_2 right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_2/clk right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_2/clkout right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_2_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_1 right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_1/clk right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_1/clkout right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_1_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_0 right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_0/clk right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_0/clkout right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_0_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/mybuff4engclkpin__78 right_stack_inst/mgtile_inst3/mybuff4engclkpin__78/clk right_stack_inst/mgtile_inst3/mybuff4engclkpin__78/clkout right_stack_inst/mgtile_inst3/mybuff4engclkpin__78_VCC VSSX i0scbf026aa1n06x5
xright_stack_inst/mgtile_inst3/mybuff4engclkpin__77 right_stack_inst/mgtile_inst3/mybuff4engclkpin__77/clk right_stack_inst/mgtile_inst3/mybuff4engclkpin__77/clkout right_stack_inst/mgtile_inst3/mybuff4engclkpin__77_VCC VSSX i0scbf026aa1n06x5
xright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_buf_cell right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_buf_cell/clk right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_buf_cell/clkout right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_buf_cell_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_6 right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_6/clk right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_6/clkout right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_6_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_5 right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_5/clk right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_5/clkout right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_5_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_4 right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_4/clk right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_4/clkout right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_4_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_3 right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_3/clk right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_3/clkout right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_3_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_2 right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_2/clk right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_2/clkout right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_2_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_1 right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_1/clk right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_1/clkout right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_1_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_0 right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_0/clk right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_0/clkout right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_0_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/mybuff4engclkpin__74 right_stack_inst/mgtile_inst3/mybuff4engclkpin__74/clk right_stack_inst/mgtile_inst3/mybuff4engclkpin__74/clkout right_stack_inst/mgtile_inst3/mybuff4engclkpin__74_VCC VSSX i0scbf026aa1n06x5
xright_stack_inst/mgtile_inst3/mybuff4engclkpin__72 right_stack_inst/mgtile_inst3/mybuff4engclkpin__72/clk right_stack_inst/mgtile_inst3/mybuff4engclkpin__72/clkout right_stack_inst/mgtile_inst3/mybuff4engclkpin__72_VCC VSSX i0scbf026aa1n06x5
xright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_buf_cell right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_buf_cell/clk right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_buf_cell/clkout right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_buf_cell_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_6 right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_6/clk right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_6/clkout right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_6_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_5 right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_5/clk right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_5/clkout right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_5_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_4 right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_4/clk right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_4/clkout right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_4_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_3 right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_3/clk right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_3/clkout right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_3_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_2 right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_2/clk right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_2/clkout right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_2_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_1 right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_1/clk right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_1/clkout right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_1_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_0 right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_0/clk right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_0/clkout right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_0_VCC VSSX i0scinv00aa1n18x5
xright_stack_inst/mgtile_inst3/mybuff4engclkpin__70 right_stack_inst/mgtile_inst3/mybuff4engclkpin__70/clk right_stack_inst/mgtile_inst3/mybuff4engclkpin__70/clkout right_stack_inst/mgtile_inst3/mybuff4engclkpin__70_VCC VSSX i0scbf026aa1n06x5
xright_stack_inst/mgtile_inst3/mybuff4engclkpin__69 right_stack_inst/mgtile_inst3/mybuff4engclkpin__69/clk right_stack_inst/mgtile_inst3/mybuff4engclkpin__69/clkout right_stack_inst/mgtile_inst3/mybuff4engclkpin__69_VCC VSSX i0scbf026aa1n06x5
xright_stack_inst/mgtile_inst3/myflop4engclkpin__70 right_stack_inst/mgtile_inst3/myflop4engclkpin__70/clk right_stack_inst/mgtile_inst3/myflop4engclkpin__70/d right_stack_inst/mgtile_inst3/myflop4engclkpin__70/ob right_stack_inst/mgtile_inst3/myflop4engclkpin__70/s
