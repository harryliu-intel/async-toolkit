vright_stack_inst/mgtile_inst3/mynet4Octa_engclkpin__68_right_stack_inst/mgtile_inst3/mybuff4Octa_engclkpin__68/clkout	right_stack_inst/mgtile_inst3/mynet4Octa_engclkpin__68	right_stack_inst/mgtile_inst3/mybuff4Octa_engclkpin__68/clkout	0
vright_stack_inst/mgtile_inst3/mynet4Octa_engclkpin__68_right_stack_inst/mgtile_inst3/myOctaFlop/clk	right_stack_inst/mgtile_inst3/mynet4Octa_engclkpin__68	right_stack_inst/mgtile_inst3/myOctaFlop/clk	0
vbzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux_vcc bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani_vcc bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_297_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_297_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_296_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_296_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_295_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_295_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_294_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_294_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_293_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_293_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_292_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_292_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_291_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_291_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_260_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_260_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_290_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_290_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_289_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_289_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_288_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_288_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_287_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_287_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_286_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_286_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_285_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_285_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_284_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_284_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_283_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_283_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_262_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_262_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_282_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_282_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_281_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_281_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_280_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_280_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_279_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_279_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_278_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_278_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_277_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_277_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_276_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_276_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_275_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_275_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_265_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_265_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_274_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_274_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_273_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_273_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_272_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_272_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_271_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_271_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_270_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_270_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_269_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_269_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_268_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_268_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_267_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_267_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_266_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_266_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_vcc_in bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_VCC_IN 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_vcc_out bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_VCC_OUT 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_352_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_352_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_rt_3_sch_vcc right_stack_inst/mgtile_inst3/clk_buf_rt_3_sch_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_351_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_351_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_350_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_350_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_349_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_349_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_348_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_348_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_347_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_347_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_346_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_346_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_345_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_345_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_344_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_344_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_343_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_343_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_342_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_342_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_341_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_341_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_340_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_340_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_339_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_339_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_338_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_338_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_337_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_337_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_336_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_336_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_335_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_335_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_334_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_334_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_333_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_333_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_332_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_332_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_331_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_331_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_330_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_330_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_329_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_329_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_328_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_328_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_327_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_327_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_326_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_326_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_325_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_325_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_324_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_324_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_323_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_323_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_322_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_322_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_321_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_321_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_320_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_320_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_319_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_319_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_318_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_318_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_317_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_317_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_316_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_316_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_315_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_315_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_314_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_314_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_313_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_313_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_312_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_312_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_311_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_311_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_310_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_310_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_309_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_309_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_308_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_308_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_307_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_307_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_306_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_306_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_305_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_305_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_304_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_304_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_303_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_303_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_302_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_302_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_301_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_301_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_300_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_300_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_299_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_299_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_298_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_298_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9_VCC 0 vminer
vright_stack_inst/mgtile_inst3/mybuff4Octa_engclkpin__69_vcc right_stack_inst/mgtile_inst3/mybuff4Octa_engclkpin__69_VCC 0 vminer
vright_stack_inst/mgtile_inst3/mybuff4Octa_engclkpin__68_vcc right_stack_inst/mgtile_inst3/mybuff4Octa_engclkpin__68_VCC 0 vminer
vright_stack_inst/mgtile_inst3/myOctaFlop_vcc right_stack_inst/mgtile_inst3/myOctaFlop_VCC 0 vminer
vbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clk1	bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clk1	0	vtrue
vbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/s	bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/s	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/rb	0	vtrue
vright_stack_inst/mgtile_inst3/myOctaFlop/d	right_stack_inst/mgtile_inst3/myOctaFlop/d	0	vminer
vright_stack_inst/mgtile_inst3/myOctaFlop/s	right_stack_inst/mgtile_inst3/myOctaFlop/s	0	0
