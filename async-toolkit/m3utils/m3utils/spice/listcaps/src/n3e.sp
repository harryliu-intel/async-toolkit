.include 'n3e_elvt.sp'

.include 'n3e_ulvt.sp'

.include '/nfs/site/disks/zsc3_fon_fe_0001/mnystroe/BTC4/BTC4/tsmchack/n3e.sp'

.include '/nfs/site/disks/zsc3_fon_fe_0001/mnystroe/BTC4/BTC4/tsmchack/g1i_tsmc_1.hspice'

.include '/nfs/site/disks/zsc3_fon_fe_0001/mnystroe/BTC4/BTC4/tsmchack/cell.hspice'
