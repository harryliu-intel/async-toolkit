.probe tran v(xbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/clk1)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/clk2)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140569)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140569/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140569/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140569_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140568)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140568/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140568/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140568_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124089)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124089/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124089/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124089_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/bzmpll_inst0/clock_opt_cts_ZCTSINV_745_138433)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/clock_opt_cts_ZCTSINV_745_138433/clk)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/clock_opt_cts_ZCTSINV_745_138433/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/clock_opt_cts_ZCTSINV_745_138433_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/notch_dcc_inst0/clock_opt_cts_engclk_i_vtd123961)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/clock_opt_cts_engclk_i_vtd123961/clk)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/clock_opt_cts_engclk_i_vtd123961/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/clock_opt_cts_engclk_i_vtd123961_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux)
.probe tran v(bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clk1)
.probe tran v(bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clk2)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani)
.probe tran v(bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/clk)
.probe tran v(bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/clkout)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_391)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_391/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_391/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_391_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_390)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_390/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_390/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_390_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_389)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_389/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_389/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_389_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_388)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_388/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_388/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_388_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_387)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_387/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_387/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_387_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_386)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_386/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_386/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_386_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_355)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_355/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_355/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_355_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_385)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_385/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_385/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_385_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_384)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_384/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_384/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_384_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_383)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_383/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_383/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_383_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_382)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_382/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_382/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_382_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_381)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_381/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_381/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_381_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_380)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_380/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_380/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_380_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_379)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_379/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_379/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_379_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_378)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_378/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_378/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_378_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_377)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_377/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_377/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_377_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_356)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_356/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_356/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_356_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_376)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_376/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_376/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_376_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_375)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_375/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_375/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_375_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_374)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_374/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_374/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_374_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_373)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_373/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_373/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_373_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_372)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_372/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_372/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_372_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_371)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_371/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_371/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_371_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_370)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_370/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_370/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_370_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_369)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_369/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_369/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_369_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_359)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_359/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_359/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_359_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_368)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_368/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_368/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_368_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_367)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_367/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_367/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_367_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_366)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_366/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_366/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_366_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_365)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_365/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_365/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_365_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_364)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_364/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_364/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_364_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_363)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_363/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_363/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_363_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_362)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_362/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_362/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_362_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_361)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_361/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_361/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_361_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_360)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_360/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_360/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_360_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift/clkout)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_497)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_497/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_497/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_497_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_rt_3_sch)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_rt_3_sch/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_rt_3_sch/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_rt_3_sch_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_496)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_496/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_496/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_496_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_495)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_495/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_495/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_495_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_494)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_494/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_494/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_494_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_493)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_493/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_493/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_493_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_492)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_492/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_492/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_492_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_491)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_491/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_491/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_491_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_490)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_490/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_490/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_490_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_489)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_489/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_489/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_489_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_488)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_488/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_488/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_488_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_487)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_487/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_487/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_487_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_486)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_486/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_486/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_486_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_485)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_485/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_485/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_485_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_484)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_484/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_484/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_484_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_483)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_483/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_483/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_483_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_482)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_482/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_482/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_482_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_481)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_481/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_481/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_481_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_480)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_480/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_480/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_480_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_479)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_479/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_479/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_479_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_478)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_478/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_478/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_478_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_477)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_477/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_477/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_477_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_476)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_476/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_476/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_476_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_475)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_475/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_475/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_475_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_474)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_474/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_474/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_474_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_473)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_473/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_473/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_473_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_472)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_472/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_472/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_472_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_471)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_471/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_471/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_471_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_470)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_470/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_470/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_470_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_469)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_469/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_469/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_469_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_468)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_468/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_468/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_468_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_467)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_467/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_467/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_467_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_466)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_466/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_466/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_466_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_465)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_465/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_465/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_465_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_464)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_464/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_464/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_464_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_463)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_463/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_463/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_463_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_462)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_462/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_462/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_462_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_461)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_461/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_461/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_461_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_460)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_460/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_460/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_460_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_459)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_459/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_459/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_459_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_458)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_458/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_458/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_458_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_457)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_457/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_457/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_457_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_456)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_456/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_456/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_456_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_455)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_455/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_455/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_455_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_454)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_454/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_454/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_454_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_453)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_453/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_453/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_453_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_452)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_452/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_452/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_452_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_451)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_451/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_451/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_451_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_450)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_450/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_450/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_450_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_449)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_449/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_449/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_449_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_448)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_448/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_448/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_448_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_447)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_447/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_447/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_447_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_446)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_446/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_446/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_446_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_445)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_445/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_445/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_445_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/my_flop)
.probe tran v(right_stack_inst/mgtile_inst3/my_flop/clk)
.probe tran v(right_stack_inst/mgtile_inst3/my_flop/d)
.probe tran v(xright_stack_inst/mgtile_inst3/U43)
.probe tran v(right_stack_inst/mgtile_inst3/U43/clk)
.probe tran v(right_stack_inst/mgtile_inst3/U43/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/U43_VCC)
