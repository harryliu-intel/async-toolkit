vsp_fast_clk_right_postls_3_u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_3_lvl_spine2lstack_engclk_ctech_lvlshift/clkout	sp_fast_clk_right_postls_3	u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_3_lvl_spine2lstack_engclk_ctech_lvlshift/clkout	0
vsp_fast_clk_right_postls_3_right_stack_inst/mybuff4engclkpin__84/clk	sp_fast_clk_right_postls_3	right_stack_inst/mybuff4engclkpin__84/clk	0
vright_stack_inst/mynet4engclkpin__84_right_stack_inst/mybuff4engclkpin__84/clkout	right_stack_inst/mynet4engclkpin__84	right_stack_inst/mybuff4engclkpin__84/clkout	0
vright_stack_inst/mynet4engclkpin__84_right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_0/clk	right_stack_inst/mynet4engclkpin__84	right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_0/clk	0
vright_stack_inst/mgtile_inst3/mynet4engclkpin__70_right_stack_inst/mgtile_inst3/mybuff4engclkpin__70/clkout	right_stack_inst/mgtile_inst3/mynet4engclkpin__70	right_stack_inst/mgtile_inst3/mybuff4engclkpin__70/clkout	0
vright_stack_inst/mgtile_inst3/mynet4engclkpin__70_right_stack_inst/mgtile_inst3/myflop4engclkpin__70/clk	right_stack_inst/mgtile_inst3/mynet4engclkpin__70	right_stack_inst/mgtile_inst3/myflop4engclkpin__70/clk	0
vbzmnotchwrap/bzmnotch/bzmpll_inst0/pll_fast_clk_by2_reg_vcc bzmnotchwrap/bzmnotch/bzmpll_inst0/pll_fast_clk_by2_reg_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/bzmpll_inst0/ctmi_225_vcc bzmnotchwrap/bzmnotch/bzmpll_inst0/ctmi_225_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1_vcc bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1_C_SPC0_vcc bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1_C_SPC0_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_2to1_vcc bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_2to1_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/bzmpll_inst0/fast_clk_count_reg_0_vcc bzmnotchwrap/bzmnotch/bzmpll_inst0/fast_clk_count_reg_0_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/bzmpll_inst0/pwc_clk_gate_fast_clk_count_reg_1_vcc bzmnotchwrap/bzmnotch/bzmpll_inst0/pwc_clk_gate_fast_clk_count_reg_1_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_72_vcc bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_72_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_58_vcc bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_58_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67_vcc bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_73_vcc bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_73_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_57_vcc bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_57_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67_2inv_eco_cell_vcc bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67_2inv_eco_cell_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_0_vcc bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_0_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_1_vcc bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_1_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_2_vcc bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_2_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_3_vcc bzmnotchwrap/bzmnotch/notch_eng_clk_RT_inv_cell_n2n_lvl_3_VCC 0 vtrue
vbzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift_vcc_in bzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift_VCC_IN 0 vtrue
vbzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift_vcc_out bzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift_VCC_OUT 0 vnotch
vspinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_0_vcc spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_0_VCC 0 vnotch
vspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_0_vcc spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_0_VCC 0 vnotch
vspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_1_vcc spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_1_VCC 0 vnotch
vspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_2_vcc spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_2_VCC 0 vnotch
vspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_3_vcc spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_3_VCC 0 vnotch
vspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_4_vcc spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_4_VCC 0 vnotch
vspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_5_vcc spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_5_VCC 0 vnotch
vspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_6_vcc spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_6_VCC 0 vnotch
vspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_7_vcc spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_7_VCC 0 vnotch
vspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_8_vcc spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_8_VCC 0 vnotch
vspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_9_vcc spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_9_VCC 0 vnotch
vspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_10_vcc spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_10_VCC 0 vnotch
vspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_11_vcc spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_11_VCC 0 vnotch
vspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_12_vcc spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_12_VCC 0 vnotch
vspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_13_vcc spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_13_VCC 0 vnotch
vspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_14_vcc spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_14_VCC 0 vnotch
vspinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_15_vcc spinewrap_inst/met1and0_eng_clk_RT_inv_cell_s2lt_lvl_15_VCC 0 vnotch
vspinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_1_vcc spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_1_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_0_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_0_VCC 0 vnotch
vu_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_1_lvl_spine2lstack_engclk_ctech_lvlshift_vcc_in u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_1_lvl_spine2lstack_engclk_ctech_lvlshift_VCC_IN 0 vnotch
vu_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_1_lvl_spine2lstack_engclk_ctech_lvlshift_vcc_out u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_1_lvl_spine2lstack_engclk_ctech_lvlshift_VCC_OUT 0 'vminer'
vu_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_0_lvl_spine2lstack_engclk_ctech_lvlshift_vcc_in u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_0_lvl_spine2lstack_engclk_ctech_lvlshift_VCC_IN 0 vnotch
vu_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_0_lvl_spine2lstack_engclk_ctech_lvlshift_vcc_out u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_0_lvl_spine2lstack_engclk_ctech_lvlshift_VCC_OUT 0 'vminer'
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_1_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_1_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_2_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_2_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_3_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_3_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_4_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_4_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_5_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_5_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_6_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_6_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_7_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_7_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_8_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_8_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_9_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_9_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_10_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_10_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_11_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_11_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_12_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_12_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_13_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_13_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_14_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_14_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_15_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_15_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_16_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_16_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_17_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_17_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_18_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_18_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_19_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_19_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_20_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_20_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_21_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_21_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_22_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_22_VCC 0 vnotch
vspinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_23_vcc spinewrap_inst/met7and6_eng_clk_RT_inv_cell_s2lt_lvl_23_VCC 0 vnotch
vspinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_2_vcc spinewrap_inst/met_eng_clk_RT_lvl_buf_cell_s2lt_lvl_2_VCC 0 vnotch
vu_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_3_lvl_spine2lstack_engclk_ctech_lvlshift_vcc_in u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_3_lvl_spine2lstack_engclk_ctech_lvlshift_VCC_IN 0 vnotch
vu_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_3_lvl_spine2lstack_engclk_ctech_lvlshift_vcc_out u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_3_lvl_spine2lstack_engclk_ctech_lvlshift_VCC_OUT 0 'vminer'
vu_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_2_lvl_spine2lstack_engclk_ctech_lvlshift_vcc_in u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_2_lvl_spine2lstack_engclk_ctech_lvlshift_VCC_IN 0 vnotch
vu_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_2_lvl_spine2lstack_engclk_ctech_lvlshift_vcc_out u_fwr_spine2rstack_ls_wrap/spine2lstack_engclk_2_lvl_spine2lstack_engclk_ctech_lvlshift_VCC_OUT 0 'vminer'
vright_stack_inst/mybuff4engclkpin__84_vcc right_stack_inst/mybuff4engclkpin__84_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_0_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_0_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_1_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_1_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_2_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_2_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_3_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_3_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_4_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_4_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_5_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_5_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_6_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_6_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_7_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_7_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_8_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_8_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_9_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_9_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_10_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_10_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_11_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_11_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_12_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_12_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_13_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_13_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/sch_wrapper_eng_clk_RT_inv_cell_2lvl_0_vcc right_stack_inst/mgtile_inst3/sch_wrapper_eng_clk_RT_inv_cell_2lvl_0_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_14_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_14_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_15_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_2lvl_15_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_buf_cell_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_buf_cell_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_3_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_eng_clk_RT_inv_cell_3_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_0_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_0_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_1_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_1_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_2_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_2_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_3_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_3_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_4_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_4_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_5_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_5_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_6_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_6_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_7_vcc right_stack_inst/mgtile_inst3/octa_wrapper_8and15_to_0and7_eng_clk_RT_inv_cell_7_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_buf_cell_vcc right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_buf_cell_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_3_vcc right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_3_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_2_vcc right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_2_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_1_vcc right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_1_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_0_vcc right_stack_inst/mgtile_inst3/octa_wrapper_0and7_eng_clk_RT_inv_cell_0_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/mybuff4engclkpin__82_vcc right_stack_inst/mgtile_inst3/mybuff4engclkpin__82_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/mybuff4engclkpin__81_vcc right_stack_inst/mgtile_inst3/mybuff4engclkpin__81_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_buf_cell_vcc right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_buf_cell_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_6_vcc right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_6_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_5_vcc right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_5_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_4_vcc right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_4_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_3_vcc right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_3_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_2_vcc right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_2_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_1_vcc right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_1_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_0_vcc right_stack_inst/mgtile_inst3/octa_wrapper_1and6_eng_clk_RT_inv_cell_0_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/mybuff4engclkpin__78_vcc right_stack_inst/mgtile_inst3/mybuff4engclkpin__78_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/mybuff4engclkpin__77_vcc right_stack_inst/mgtile_inst3/mybuff4engclkpin__77_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_buf_cell_vcc right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_buf_cell_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_6_vcc right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_6_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_5_vcc right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_5_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_4_vcc right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_4_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_3_vcc right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_3_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_2_vcc right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_2_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_1_vcc right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_1_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_0_vcc right_stack_inst/mgtile_inst3/octa_wrapper_2and5_eng_clk_RT_inv_cell_0_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/mybuff4engclkpin__74_vcc right_stack_inst/mgtile_inst3/mybuff4engclkpin__74_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/mybuff4engclkpin__72_vcc right_stack_inst/mgtile_inst3/mybuff4engclkpin__72_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_buf_cell_vcc right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_buf_cell_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_6_vcc right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_6_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_5_vcc right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_5_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_4_vcc right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_4_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_3_vcc right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_3_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_2_vcc right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_2_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_1_vcc right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_1_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_0_vcc right_stack_inst/mgtile_inst3/octa_wrapper_3and4_eng_clk_RT_inv_cell_0_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/mybuff4engclkpin__70_vcc right_stack_inst/mgtile_inst3/mybuff4engclkpin__70_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/mybuff4engclkpin__69_vcc right_stack_inst/mgtile_inst3/mybuff4engclkpin__69_VCC 0 'vminer'
vright_stack_inst/mgtile_inst3/myflop4engclkpin__70_vcc right_stack_inst/mgtile_inst3/myflop4engclkpin__70_VCC 0 'vminer'
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1/b	bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1/b	0	0
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1/sa	bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1/sa	0	vtrue
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1_C_SPC0/a	bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1_C_SPC0/a	0	0
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1_C_SPC0/b	bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1_C_SPC0/b	0	0
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1_C_SPC0/sa	bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux_ctech_clk_mux_2to1_C_SPC0/sa	0	0
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_2to1/a	bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_2to1/a	0	0
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_2to1/sa	bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_2to1/sa	0	0
vbzmnotchwrap/bzmnotch/bzmpll_inst0/fast_clk_count_reg_0/d	bzmnotchwrap/bzmnotch/bzmpll_inst0/fast_clk_count_reg_0/d	0	0
vbzmnotchwrap/bzmnotch/bzmpll_inst0/fast_clk_count_reg_0/rb	bzmnotchwrap/bzmnotch/bzmpll_inst0/fast_clk_count_reg_0/rb	0	vtrue
vbzmnotchwrap/bzmnotch/bzmpll_inst0/pwc_clk_gate_fast_clk_count_reg_1/en	bzmnotchwrap/bzmnotch/bzmpll_inst0/pwc_clk_gate_fast_clk_count_reg_1/en	0	vtrue
vbzmnotchwrap/bzmnotch/bzmpll_inst0/pwc_clk_gate_fast_clk_count_reg_1/te	bzmnotchwrap/bzmnotch/bzmpll_inst0/pwc_clk_gate_fast_clk_count_reg_1/te	0	0
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_72/b	bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_72/b	0	0
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67/a	bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67/a	0	vtrue
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67/c	bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67/c	0	vtrue
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67/d	bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67/d	0	vtrue
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67/e	bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67/e	0	0
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67/f	bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_67/f	0	vtrue
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_73/b	bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_73/b	0	0
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_73/c	bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_73/c	0	0
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_73/d	bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_73/d	0	vtrue
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_57/b	bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_57/b	0	0
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_57/c	bzmnotchwrap/bzmnotch/notch_dcc_inst0/ctmi_57/c	0	0
vbzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift/gne1_vo	bzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift/gne1_vo	0	vnotch
vbzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift/gns2_vo	bzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift/gns2_vo	0	vnotch
vbzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift/gpe1_vo	bzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift/gpe1_vo	0	0
vbzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift/gps2_vo	bzmnotchwrap/fwr_notch2spine_ls_wrap/right_stack_engclk_ctech_dcc_lvlshift/gps2_vo	0	0
vright_stack_inst/mgtile_inst3/myflop4engclkpin__70/d	right_stack_inst/mgtile_inst3/myflop4engclkpin__70/d	0	'vminer'
vright_stack_inst/mgtile_inst3/myflop4engclkpin__70/s	right_stack_inst/mgtile_inst3/myflop4engclkpin__70/s	0	0
