.probe tran v(xbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/clk1)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/clk2)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140569)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140569/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140569/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140569_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140568)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140568/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140568/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140568_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124089)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124089/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124089/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124089_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/bzmpll_inst0/clock_opt_cts_ZCTSINV_745_138433)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/clock_opt_cts_ZCTSINV_745_138433/clk)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/clock_opt_cts_ZCTSINV_745_138433/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/bzmpll_inst0/clock_opt_cts_ZCTSINV_745_138433_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/notch_dcc_inst0/clock_opt_cts_engclk_i_vtd123961)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/clock_opt_cts_engclk_i_vtd123961/clk)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/clock_opt_cts_engclk_i_vtd123961/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/notch_dcc_inst0/clock_opt_cts_engclk_i_vtd123961_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux)
.probe tran v(bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clk1)
.probe tran v(bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clk2)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/d)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/d)
.probe tran v(xbzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani)
.probe tran v(bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/clk)
.probe tran v(bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/clkout)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_eng_rt_focal_buf)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_eng_rt_focal_buf/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_eng_rt_focal_buf/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_eng_rt_focal_buf_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2318)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2318/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2318/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2318_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2317)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2317/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2317/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2317_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2316)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2316/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2316/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2316_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2315)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2315/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2315/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2315_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2314)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2314/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2314/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2314_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2313)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2313/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2313/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2313_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2282)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2282/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2282/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2282_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2312)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2312/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2312/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2312_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2311)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2311/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2311/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2311_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2310)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2310/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2310/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2310_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2309)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2309/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2309/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2309_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2308)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2308/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2308/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2308_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2307)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2307/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2307/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2307_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2306)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2306/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2306/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2306_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2305)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2305/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2305/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2305_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2304)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2304/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2304/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2304_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2283)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2283/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2283/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2283_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2303)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2303/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2303/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2303_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2302)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2302/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2302/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2302_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2301)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2301/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2301/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2301_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2300)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2300/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2300/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2300_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2299)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2299/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2299/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2299_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2298)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2298/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2298/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2298_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2297)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2297/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2297/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2297_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2296)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2296/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2296/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2296_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2286)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2286/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2286/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2286_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2295)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2295/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2295/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2295_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2294)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2294/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2294/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2294_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2293)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2293/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2293/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2293_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2292)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2292/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2292/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2292_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2291)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2291/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2291/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2291_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2290)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2290/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2290/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2290_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2289)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2289/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2289/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2289_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2288)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2288/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2288/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2288_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2287)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2287/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2287/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_2287_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift/clkout)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2371)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2371/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2371/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2371_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2370)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2370/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2370/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2370_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_rt_3_sch)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_rt_3_sch/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_rt_3_sch/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_rt_3_sch_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2369)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2369/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2369/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2369_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2368)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2368/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2368/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2368_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2367)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2367/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2367/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2367_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2366)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2366/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2366/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2366_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2365)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2365/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2365/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2365_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2364)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2364/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2364/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2364_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2363)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2363/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2363/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2363_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2362)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2362/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2362/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2362_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2361)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2361/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2361/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2361_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2360)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2360/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2360/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2360_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2359)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2359/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2359/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2359_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2358)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2358/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2358/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2358_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2357)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2357/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2357/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2357_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2356)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2356/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2356/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2356_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2355)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2355/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2355/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2355_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2354)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2354/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2354/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2354_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2353)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2353/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2353/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2353_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2352)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2352/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2352/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2352_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2351)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2351/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2351/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2351_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2350)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2350/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2350/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2350_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2349)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2349/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2349/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2349_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2348)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2348/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2348/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2348_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2347)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2347/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2347/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2347_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2346)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2346/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2346/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2346_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2345)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2345/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2345/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2345_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2344)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2344/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2344/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2344_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2343)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2343/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2343/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2343_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2342)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2342/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2342/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2342_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2341)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2341/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2341/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2341_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2340)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2340/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2340/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2340_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2339)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2339/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2339/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2339_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2338)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2338/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2338/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2338_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2337)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2337/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2337/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2337_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2336)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2336/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2336/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2336_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2335)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2335/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2335/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2335_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2334)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2334/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2334/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2334_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2333)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2333/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2333/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2333_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2332)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2332/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2332/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2332_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2331)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2331/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2331/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2331_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2330)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2330/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2330/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2330_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2329)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2329/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2329/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2329_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2328)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2328/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2328/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2328_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2327)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2327/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2327/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2327_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2326)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2326/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2326/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2326_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2325)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2325/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2325/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2325_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2324)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2324/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2324/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2324_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2323)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2323/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2323/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2323_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2322)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2322/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2322/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2322_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2321)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2321/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2321/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2321_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2320)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2320/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2320/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2320_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_RT_2319)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2319/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2319/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_RT_2319_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/my_flop)
.probe tran v(right_stack_inst/mgtile_inst3/my_flop/clk)
.probe tran v(right_stack_inst/mgtile_inst3/my_flop/d)
.probe tran v(xright_stack_inst/mgtile_inst3/U15)
.probe tran v(right_stack_inst/mgtile_inst3/U15/clk)
.probe tran v(right_stack_inst/mgtile_inst3/U15/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/U15_VCC)
