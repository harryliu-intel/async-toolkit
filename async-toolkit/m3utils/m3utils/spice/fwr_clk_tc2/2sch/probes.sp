.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux)
.probe tran v(bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clk1)
.probe tran v(bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clk2)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210/clk)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210/clkout)
.probe tran v(bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210_VCC)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/o)
.probe tran v(xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/clk)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/d)
.probe tran v(bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/o)
.probe tran v(xbzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani)
.probe tran v(bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/clk)
.probe tran v(bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/clkout)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_297)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_297/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_297/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_297_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_296)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_296/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_296/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_296_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_295)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_295/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_295/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_295_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_294)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_294/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_294/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_294_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_293)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_293/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_293/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_293_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_292)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_292/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_292/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_292_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_291)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_291/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_291/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_291_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_260)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_260/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_260/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_260_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_290)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_290/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_290/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_290_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_289)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_289/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_289/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_289_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_288)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_288/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_288/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_288_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_287)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_287/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_287/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_287_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_286)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_286/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_286/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_286_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_285)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_285/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_285/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_285_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_284)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_284/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_284/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_284_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_283)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_283/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_283/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_283_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_262)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_262/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_262/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_262_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_282)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_282/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_282/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_282_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_281)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_281/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_281/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_281_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_280)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_280/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_280/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_280_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_279)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_279/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_279/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_279_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_278)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_278/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_278/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_278_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_277)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_277/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_277/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_277_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_276)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_276/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_276/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_276_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_275)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_275/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_275/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_275_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_265)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_265/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_265/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_265_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_274)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_274/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_274/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_274_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_273)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_273/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_273/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_273_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_272)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_272/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_272/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_272_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_271)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_271/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_271/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_271_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_270)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_270/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_270/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_270_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_269)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_269/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_269/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_269_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_268)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_268/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_268/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_268_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_267)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_267/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_267/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_267_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_266)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_266/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_266/clkout)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_266_VCC)
.probe tran v(xbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift/clk)
.probe tran v(bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift/clkout)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_352)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_352/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_352/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_352_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_rt_3_sch)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_rt_3_sch/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_rt_3_sch/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_rt_3_sch_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_351)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_351/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_351/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_351_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_350)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_350/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_350/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_350_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_349)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_349/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_349/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_349_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_348)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_348/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_348/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_348_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_347)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_347/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_347/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_347_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_346)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_346/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_346/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_346_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_345)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_345/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_345/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_345_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_344)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_344/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_344/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_344_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_343)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_343/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_343/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_343_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_342)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_342/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_342/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_342_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_341)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_341/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_341/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_341_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_340)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_340/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_340/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_340_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_339)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_339/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_339/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_339_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_338)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_338/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_338/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_338_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_337)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_337/clk)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_337/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_337_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/mybuff4Octa_engclkpin__59)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4Octa_engclkpin__59/clk)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4Octa_engclkpin__59/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4Octa_engclkpin__59_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/mybuff4Octa_engclkpin__58)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4Octa_engclkpin__58/clk)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4Octa_engclkpin__58/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4Octa_engclkpin__58_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_1)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_1/clk)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_1/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_1_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_2)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_2/clk)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_2/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_2_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_3)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_3/clk)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_3/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_3_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_4)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_4/clk)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_4/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_4_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_5)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_5/clk)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_5/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_5_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_6)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_6/clk)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_6/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_6_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_7)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_7/clk)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_7/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_7_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_8)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_8/clk)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_8/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_8_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_9)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_9/clk)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_9/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_9_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_10)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_10/clk)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_10/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_10_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_11)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_11/clk)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_11/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_11_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_12)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_12/clk)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_12/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_12_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_13)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_13/clk)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_13/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_13_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_14)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_14/clk)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_14/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_14_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/mybuff4Sch_engclkpin__3)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4Sch_engclkpin__3/clk)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4Sch_engclkpin__3/clkout)
.probe tran v(right_stack_inst/mgtile_inst3/mybuff4Sch_engclkpin__3_VCC)
.probe tran v(xright_stack_inst/mgtile_inst3/mySchFlop)
.probe tran v(right_stack_inst/mgtile_inst3/mySchFlop/clk)
.probe tran v(right_stack_inst/mgtile_inst3/mySchFlop/d)
