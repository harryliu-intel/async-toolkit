.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0maboi22aa1n02x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0mand002aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0maoai13aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0maoai13aa1n02x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0maoai13aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0maob012aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0maob012aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0maoi012aa1n02x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0maoi012aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0maoi013aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0maoi112aa1n02x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0maoi112aa1n03x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0maoi122aa1n02x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0maoib12aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/seq_ulvt/spf/lib783_i0m_180h_50pp_seq_ulvt_100c_tttt_cmax/i0mfun400aa1q02x6.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/seq_ulvt/spf/lib783_i0m_180h_50pp_seq_ulvt_100c_tttt_cmax/i0mfun400aa1q03x6.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0minv000aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0mmtn022aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0mnanb02aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0mnanb02aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0mnand02aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0mnano22aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0mnanp02aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0mnona22aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0mnona23aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0mnona32aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0mnor002aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0mnorb02aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0mnorb02aa1n02x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0mnorb02aa1n03x4.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0mnorp02aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0moa0012aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0moab012aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0moab012aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0moabi12aa1n02x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0moai012aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0moai012aa1n02x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0moai012aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0moai112aa1n02x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0moai112aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0moai122aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0moaib12aa1n02x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0moaih12aa1n02x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0morn002aa1n02x7.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0morn002aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0mxnrc02aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0mxobna2aa1n03x5.spf"
.include "/p/hdk/cad/stdcells/lib783_i0m_180h_50pp/pdk080_r4v2p0_efv/base_ulvt/spf/lib783_i0m_180h_50pp_base_ulvt_100c_tttt_cmax/i0mxorc02aa1n03x5.spf"
