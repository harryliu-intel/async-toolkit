.INCLUDE 'my_devices.spi'
.INCLUDE 'short.spi'
.INCLUDE 'tphn7_18gpio.spi'
