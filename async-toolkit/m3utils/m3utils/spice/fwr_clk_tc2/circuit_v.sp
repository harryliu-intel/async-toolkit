vright_stack_inst/mgtile_inst3/clk_net_3_rt_mgtile_6_9_right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9/clkout	right_stack_inst/mgtile_inst3/clk_net_3_rt_mgtile_6_9	right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9/clkout	0
vright_stack_inst/mgtile_inst3/clk_net_3_rt_mgtile_6_9_right_stack_inst/mgtile_inst3/my_flop/clk	right_stack_inst/mgtile_inst3/clk_net_3_rt_mgtile_6_9	right_stack_inst/mgtile_inst3/my_flop/clk	0
vright_stack_inst/mgtile_inst3/clk_net_3_rt_mgtile_6_9_right_stack_inst/mgtile_inst3/U36/clk	right_stack_inst/mgtile_inst3/clk_net_3_rt_mgtile_6_9	right_stack_inst/mgtile_inst3/U36/clk	0
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_vcc bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140569_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140569_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140568_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_ctosc_drc_inst_140568_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124089_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124089_VCC 0 vtrue
*vbzmnotchwrap/bzmnotch/bzmpll_inst0/clock_opt_cts_ZCTSINV_745_138433_vcc xbzmnotchwrap/bzmnotch/bzmpll_inst0/clock_opt_cts_ZCTSINV_745_138433.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/notch_dcc_inst0/clock_opt_cts_engclk_i_vtd123961_vcc bzmnotchwrap/bzmnotch/notch_dcc_inst0/clock_opt_cts_engclk_i_vtd123961_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux_vcc bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani_vcc bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_eng_rt_focal_buf_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_eng_rt_focal_buf_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_290_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_290_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_289_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_289_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_288_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_288_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_287_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_287_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_286_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_286_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_285_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_285_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_255_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_255_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_284_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_284_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_283_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_283_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_282_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_282_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_281_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_281_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_280_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_280_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_279_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_279_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_278_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_278_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_277_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_277_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_276_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_276_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_256_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_256_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_275_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_275_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_274_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_274_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_273_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_273_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_272_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_272_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_271_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_271_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_270_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_270_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_269_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_269_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_268_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_268_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_258_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_258_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_267_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_267_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_266_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_266_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_265_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_265_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_264_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_264_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_263_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_263_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_262_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_262_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_261_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_261_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_260_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_260_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_259_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_RT_259_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_vcc_in bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_VCC_IN 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_vcc_out bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_VCC_OUT 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_341_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_341_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_rt_3_sch_vcc right_stack_inst/mgtile_inst3/clk_buf_rt_3_sch_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_340_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_340_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_339_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_339_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_338_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_338_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_337_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_337_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_336_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_336_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_335_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_335_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_334_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_334_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_333_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_333_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_332_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_332_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_331_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_331_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_330_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_330_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_329_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_329_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_328_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_328_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_327_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_327_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_326_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_326_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_325_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_325_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_324_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_324_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_323_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_323_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_322_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_322_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_321_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_321_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_320_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_320_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_2_13_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_319_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_319_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_318_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_318_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_317_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_317_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_316_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_316_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_315_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_315_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_314_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_314_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_3_12_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_313_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_313_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_312_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_312_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_311_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_311_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_310_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_310_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_309_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_309_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_308_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_308_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_307_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_307_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_306_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_306_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_4_11_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_305_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_305_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_304_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_304_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_303_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_303_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_302_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_302_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_301_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_301_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_300_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_300_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_299_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_299_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_298_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_298_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_5_10_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_297_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_297_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_296_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_296_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_295_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_295_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_294_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_294_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_293_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_293_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_292_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_292_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_RT_291_vcc right_stack_inst/mgtile_inst3/clk_buf_60_RT_291_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_6_9_VCC 0 vminer
vright_stack_inst/mgtile_inst3/my_flop_vcc xright_stack_inst/mgtile_inst3/my_flop.vcc 0 vminer
vright_stack_inst/mgtile_inst3/U36_vcc right_stack_inst/mgtile_inst3/U36_VCC 0 vminer
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/clk1	bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/clk1	0	0
vbzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/s	bzmnotchwrap/bzmnotch/bzmpll_inst0/bzm_clkmux1_ctech_clk_mux/s	0	0
vbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clk1	bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clk1	0	0
vbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/s	bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/s	0	0
vbzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/en	bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/en	0	0
vbzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/te	bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani/te	0	vtrue
vright_stack_inst/mgtile_inst3/my_flop/d	right_stack_inst/mgtile_inst3/my_flop/d	0	vminer
vright_stack_inst/mgtile_inst3/my_flop/rb	right_stack_inst/mgtile_inst3/my_flop/rb	0	0
