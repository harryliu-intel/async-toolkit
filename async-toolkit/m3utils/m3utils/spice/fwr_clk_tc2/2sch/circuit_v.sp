vright_stack_inst/mgtile_inst3/mynet4Sch_engclkpin__3_right_stack_inst/mgtile_inst3/mybuff4Sch_engclkpin__3/clkout	right_stack_inst/mgtile_inst3/mynet4Sch_engclkpin__3	right_stack_inst/mgtile_inst3/mybuff4Sch_engclkpin__3/clkout	0
vright_stack_inst/mgtile_inst3/mynet4Sch_engclkpin__3_right_stack_inst/mgtile_inst3/mySchFlop/clk	right_stack_inst/mgtile_inst3/mynet4Sch_engclkpin__3	right_stack_inst/mgtile_inst3/mySchFlop/clk	0
vbzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_bzmpll_inst0_fast_clk_vip124088_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux_vcc bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1646_139212_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211_vcc bzmnotchwrap/bzmnotch/inst0_sync_32stg/clock_opt_cts_ZCTSINV_193_139211_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210_vcc bzmnotchwrap/bzmnotch/clock_opt_cts_ZCTSINV_1421_139210_VCC 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b_vcc xbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b.vcc 0 vtrue
vbzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani_vcc bzmnotchwrap/bzmnotch/eng0_clk_gate_ctech_clk_gate_mani_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_297_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_297_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_296_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_296_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_295_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_295_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_294_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_294_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_293_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_293_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_292_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_292_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_291_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_291_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_260_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_260_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_290_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_290_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_289_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_289_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_288_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_288_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_287_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_287_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_286_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_286_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_285_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_285_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_284_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_284_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_283_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_283_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_262_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_262_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_282_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_282_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_281_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_281_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_280_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_280_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_279_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_279_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_278_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_278_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_277_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_277_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_276_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_276_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_275_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_275_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_265_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_265_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_274_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_274_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_273_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_273_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_272_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_272_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_271_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_271_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_270_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_270_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_269_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_269_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_268_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_268_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_267_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_267_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_266_vcc bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/clk_buf_60_BT_RT_266_VCC 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_vcc_in bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_VCC_IN 0 vtrue
vbzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_vcc_out bzmnotchwrap/u_fwr_notch2rstack_ls_wrap/notch2rstack_engclk_3_lvl_notch2rstack_engclk_ctech_lvlshift_VCC_OUT 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_352_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_352_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_rt_3_sch_vcc right_stack_inst/mgtile_inst3/clk_buf_rt_3_sch_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_351_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_351_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_350_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_350_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_349_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_349_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_348_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_348_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_0_15_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_347_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_347_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_346_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_346_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_345_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_345_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_344_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_344_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_343_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_343_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_342_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_342_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_341_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_341_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_340_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_340_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_339_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_339_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_338_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_338_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14_vcc right_stack_inst/mgtile_inst3/clk_buf_3_rt_mgtile_1_14_VCC 0 vminer
vright_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_337_vcc right_stack_inst/mgtile_inst3/clk_buf_60_TP_RT_337_VCC 0 vminer
vright_stack_inst/mgtile_inst3/mybuff4Octa_engclkpin__59_vcc right_stack_inst/mgtile_inst3/mybuff4Octa_engclkpin__59_VCC 0 vminer
vright_stack_inst/mgtile_inst3/mybuff4Octa_engclkpin__58_vcc right_stack_inst/mgtile_inst3/mybuff4Octa_engclkpin__58_VCC 0 vminer
vright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_1_vcc right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_1_VCC 0 vminer
vright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_2_vcc right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_2_VCC 0 vminer
vright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_3_vcc right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_3_VCC 0 vminer
vright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_4_vcc right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_4_VCC 0 vminer
vright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_5_vcc right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_5_VCC 0 vminer
vright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_6_vcc right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_6_VCC 0 vminer
vright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_7_vcc right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_7_VCC 0 vminer
vright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_8_vcc right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_8_VCC 0 vminer
vright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_9_vcc right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_9_VCC 0 vminer
vright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_10_vcc right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_10_VCC 0 vminer
vright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_11_vcc right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_11_VCC 0 vminer
vright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_12_vcc right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_12_VCC 0 vminer
vright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_13_vcc right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_13_VCC 0 vminer
vright_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_14_vcc right_stack_inst/mgtile_inst3/rt_mgt3_cmn_engclk_push_cell_14_VCC 0 vminer
vright_stack_inst/mgtile_inst3/mybuff4Sch_engclkpin__3_vcc right_stack_inst/mgtile_inst3/mybuff4Sch_engclkpin__3_VCC 0 vminer
vright_stack_inst/mgtile_inst3/mySchFlop_vcc right_stack_inst/mgtile_inst3/mySchFlop_VCC 0 vminer
vbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clk1	bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/clk1	0	vtrue
vbzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/s	bzmnotchwrap/bzmnotch/dcc0_bypass_clkmux_ctech_clk_mux/s	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_4_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_15_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_13_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_9_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_11_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_7_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_5_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_14_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_3_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_12_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_8_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_10_u_dblsync_ctech_sync2_b/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_a/rb	0	vtrue
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/d	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/d	0	0
vbzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/rb	bzmnotchwrap/bzmnotch/inst0_sync_32stg/SYNC_STAGE_6_u_dblsync_ctech_sync2_b/rb	0	vtrue
vright_stack_inst/mgtile_inst3/mySchFlop/d	right_stack_inst/mgtile_inst3/mySchFlop/d	0	vminer
vright_stack_inst/mgtile_inst3/mySchFlop/s	right_stack_inst/mgtile_inst3/mySchFlop/s	0	0
